Properties of the parts of a building model (IFC2X3), part 1 of 2

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Číslo projektu
Time: 2022-05-27T15:52:52
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.0.0.383 - Exporter 21.0.0.383 - Alternativní uživatelské rozhraní 21.0.0.383
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri May 27 15:52:52 2022 * Host: LAPTOP-87QBJCQG * Database: C:\Users\Samuel\AppData\Local\Temp\d086fadd-ab6f-4cfd-b176-5ff86f2fb700\4f3df39e-3154-4fe7-ba70-205b47e1a06d\ifc * Database version: 5507 * Database creation date: Fri May 27 15:50:15 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri May 27 15:50:15 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri May 27 15:50:15 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Číslo projektu
LongName: Název projektu; Phase: Stav projektu

# IfcSite, Default
RefLatitude: 50, 5, 59, 994506; RefLongitude: 14, 29, 59, 999999; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 3

# IfcBuildingStorey: Podlaží:8mm záhlaví (3)
Name | LongName | Elevation (mm)
10NP_VZT | 10NP_VZT | 32400
11NP_VZT | 11NP_VZT | 36400
12NP_STRECHA_VZT | 12NP_STRECHA_VZT | 40100

# IfcSpace: Kancelária 1023:758211, 1023
In: 10NP_VZT
LongName: Kancelária; InteriorOrExteriorSpace: INTERNAL; Group: Výchozí:293242
Pset_SpaceCommon - Reference: Kancelária 1023

# IfcSpace: Kancelária 1025:758610, 1025
In: 10NP_VZT
LongName: Kancelária; InteriorOrExteriorSpace: INTERNAL; Group: Výchozí:293242
Pset_SpaceCommon - Reference: Kancelária 1025

# IfcSpace: Openspace 1011:735302, 1011
In: 10NP_VZT
LongName: Openspace; InteriorOrExteriorSpace: INTERNAL; Group: Výchozí:293242
Pset_SpaceCommon - Reference: Openspace 1011

# IfcSpace: Prostor 1009:881429, 1009
In: 10NP_VZT
LongName: Prostor; InteriorOrExteriorSpace: INTERNAL; Group: Výchozí:293242
Pset_SpaceCommon - Reference: Prostor 1009

# IfcSpace: Prostor 1010:879392, 1010
In: 10NP_VZT
LongName: Prostor; InteriorOrExteriorSpace: INTERNAL; Group: Výchozí:293242
Pset_SpaceCommon - Reference: Prostor 1010

# IfcSpace: Prostor 1012:879981, 1012
In: 10NP_VZT
LongName: Prostor; InteriorOrExteriorSpace: INTERNAL; Group: Výchozí:293242
Pset_SpaceCommon - Reference: Prostor 1012

# IfcSpace: Prostor 1013:881755, 1013
In: 10NP_VZT
LongName: Prostor; InteriorOrExteriorSpace: INTERNAL; Group: Výchozí:293242
Pset_SpaceCommon - Reference: Prostor 1013

# IfcSpace: Prostor 1014:881757, 1014
In: 10NP_VZT
LongName: Prostor; InteriorOrExteriorSpace: INTERNAL; Group: Výchozí:293242
Pset_SpaceCommon - Reference: Prostor 1014

# IfcSpace: Prostor 1015:881759, 1015
In: 10NP_VZT
LongName: Prostor; InteriorOrExteriorSpace: INTERNAL; Group: Výchozí:293242
Pset_SpaceCommon - Reference: Prostor 1015

# IfcSpace: Prostor 1016:881761, 1016
In: 10NP_VZT
LongName: Prostor; InteriorOrExteriorSpace: INTERNAL; Group: Výchozí:293242
Pset_SpaceCommon - Reference: Prostor 1016

# IfcSpace: Prostor 1017:881763, 1017
In: 10NP_VZT
LongName: Prostor; InteriorOrExteriorSpace: INTERNAL; Group: Výchozí:293242
Pset_SpaceCommon - Reference: Prostor 1017

# IfcSpace: Prostor 1018:881765, 1018
In: 10NP_VZT
LongName: Prostor; InteriorOrExteriorSpace: INTERNAL; Group: Výchozí:293242
Pset_SpaceCommon - Reference: Prostor 1018

# IfcSpace: Prostor 1019:881767, 1019
In: 10NP_VZT
LongName: Prostor; InteriorOrExteriorSpace: INTERNAL; Group: Výchozí:293242
Pset_SpaceCommon - Reference: Prostor 1019

# IfcSpace: Prostor 1020:881769, 1020
In: 10NP_VZT
LongName: Prostor; InteriorOrExteriorSpace: INTERNAL; Group: Výchozí:293242
Pset_SpaceCommon - Reference: Prostor 1020

# IfcSpace: Prostor 1021:881771, 1021
In: 10NP_VZT
LongName: Prostor; InteriorOrExteriorSpace: INTERNAL; Group: Výchozí:293242
Pset_SpaceCommon - Reference: Prostor 1021

# IfcSpace: Prostor 1022:881773, 1022
In: 10NP_VZT
LongName: Prostor; InteriorOrExteriorSpace: INTERNAL; Group: Výchozí:293242
Pset_SpaceCommon - Reference: Prostor 1022

# IfcSpace: Prostor 1023:881924, 1023
In: 10NP_VZT
LongName: Prostor; InteriorOrExteriorSpace: INTERNAL; Group: Výchozí:293242
Pset_SpaceCommon - Reference: Prostor 1023

# IfcSpace: Prostor 1024:882442, 1024
In: 10NP_VZT
LongName: Prostor; InteriorOrExteriorSpace: INTERNAL; Group: Výchozí:293242
Pset_SpaceCommon - Reference: Prostor 1024

# IfcSpace: Prostor 1025:882444, 1025
In: 10NP_VZT
LongName: Prostor; InteriorOrExteriorSpace: INTERNAL; Group: Výchozí:293242
Pset_SpaceCommon - Reference: Prostor 1025

# IfcSpace: Prostor 1026:883243, 1026
In: 10NP_VZT
LongName: Prostor; InteriorOrExteriorSpace: INTERNAL; Group: Výchozí:293242
Pset_SpaceCommon - Reference: Prostor 1026

# IfcSpace: Prostor 1027:883325, 1027
In: 10NP_VZT
LongName: Prostor; InteriorOrExteriorSpace: INTERNAL; Group: Výchozí:293242
Pset_SpaceCommon - Reference: Prostor 1027

# IfcBuildingElementProxy: DRU-100:DRU-100 (6)
Type - Pset_BuildingElementProxyCommon - Reference: DRU-100
Type - Pset_ManufacturerTypeInformation - Manufacturer: Lindab
Type - Pset_QuantityTakeOff - Reference: DRU-100
Pset_BuildingElementProxyCommon - sets with these values: 2
Name (DRU-100:DRU-100:...) | In | Group
928229 | 1009 | Mechanické Odvod_ZAR_2 2 | Pset_ProvisionForVoid - Width: 3 mm; Depth: 3 mm
928367 | 1009 | Mechanické Odvod_ZAR_2 2
929185 | 1009 | Mechanické Odvod_ZAR_2 2
1053367 | 1018 | Mechanické Odvod_ZAR_3 1
1053497 | 1020 | Mechanické Odvod_ZAR_3 1
1097818 | 1021 | Mechanické Odvod_ZAR_3 1

# IfcBuildingElementProxy: DRU-125:DRU-125 (3)
Type - Pset_BuildingElementProxyCommon - Reference: DRU-125
Type - Pset_ManufacturerTypeInformation - Manufacturer: Lindab
Type - Pset_QuantityTakeOff - Reference: DRU-125
Pset_BuildingElementProxyCommon - sets with these values: 2
Name (DRU-125:DRU-125:...) | In | Group
922912 | 1009 | Mechanické Odvod_ZAR_2 2 | Pset_ProvisionForVoid - Width: 3 mm; Depth: 3 mm
923073 | 1009 | Mechanické Odvod_ZAR_2 2
1053961 | 1019 | Mechanické Odvod_ZAR_3 1

# IfcBuildingElementProxy: DRU-160:DRU-160 (7)
Type - Pset_BuildingElementProxyCommon - Reference: DRU-160
Type - Pset_ManufacturerTypeInformation - Manufacturer: Lindab
Type - Pset_QuantityTakeOff - Reference: DRU-160
Pset_BuildingElementProxyCommon - sets with these values: 2
Name (DRU-160:DRU-160:...) | In | Group
745111 | 1009 | Mechanické Prívod_ZAR_2 1 | Pset_ProvisionForVoid - Width: 3 mm; Depth: 3 mm
745139 | 1009 | Mechanické Prívod_ZAR_2 1
789857 | 1009 | Mechanické Odvod_ZAR_2 2
793126 | 1011 | Mechanické Prívod_ZAR_1 1
819475 | 1011 | Mechanické Odvod_ZAR_1 1
938109 | 1009 | Mechanické Odvod_ZAR_2 2
1097560 | 1021 | Mechanické Odvod_ZAR_3 1

# IfcBuildingElementProxy: DRU-224:DRU-224 (8)
Type - Pset_BuildingElementProxyCommon - Reference: DRU-224
Type - Pset_ManufacturerTypeInformation - Manufacturer: Lindab
Type - Pset_QuantityTakeOff - Reference: DRU-224
Pset_BuildingElementProxyCommon - sets with these values: 2
Name (DRU-224:DRU-224:...) | In | Group
746304 | 1009 | Mechanické Prívod_ZAR_2 1 | Pset_ProvisionForVoid - Width: 3 mm; Depth: 3 mm
783852 | 1009 | Mechanické Prívod_ZAR_2 1
784010 | 1009 | Mechanické Prívod_ZAR_2 1
786650 | 1009 | Mechanické Odvod_ZAR_2 2
787176 | 1009 | Mechanické Odvod_ZAR_2 3; Mechanické Odvod_ZAR_2 2
803376 | 1009 | Mechanické Odvod_ZAR_2 2
819267 | 1011 | Mechanické Odvod_ZAR_1 1
936317 | 1011 | Mechanické Prívod_ZAR_1 1

# IfcBuildingElementProxy: DRU-250:DRU-250 (8)
In: 1011
Type - Pset_BuildingElementProxyCommon - Reference: DRU-250
Type - Pset_ManufacturerTypeInformation - Manufacturer: Lindab
Type - Pset_QuantityTakeOff - Reference: DRU-250
Pset_BuildingElementProxyCommon - sets with these values: 2
Group: Mechanické Prívod_ZAR_1 1
Name (DRU-250:DRU-250:...)
940650 | Pset_ProvisionForVoid - Width: 3 mm; Depth: 3 mm
940737
940875
940943
941059
941107
941315
941373

# IfcBuildingElementProxy: DRU-315:DRU-315 (4)
In: 1011
Type - Pset_BuildingElementProxyCommon - Reference: DRU-315
Type - Pset_ManufacturerTypeInformation - Manufacturer: Lindab
Type - Pset_QuantityTakeOff - Reference: DRU-315
Pset_BuildingElementProxyCommon - sets with these values: 2
Group: Mechanické Odvod_ZAR_1 1
Name (DRU-315:DRU-315:...)
820657 | Pset_ProvisionForVoid - Width: 3 mm; Depth: 3 mm
820824
821102
821159

# IfcBuildingElementProxy: SLBU 100 600:SLBU-315-600-100 (2)
In: 12NP_STRECHA_VZT
Type - Pset_BuildingElementProxyCommon - Reference: SLBU-315-600-100
Type - Pset_ManufacturerTypeInformation - Manufacturer: Lindab
Type - Pset_QuantityTakeOff - Reference: SLBU-315-600-100
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Width: 600 mm; Depth: 600 mm
Name (SLBU 100 600:SLBU-315-600-100:...) | Group
1149870 | Mechanické Odvod_ZAR_2 2
1149894 | Mechanické Prívod_ZAR_2 1

# IfcBuildingElementProxy: SLRS 1750:SLRS-200-70-810-760-1750, SLRS 1750:SLRS-200-70-810-760-1750:1143067
In: 12NP_STRECHA_VZT
Type - Pset_BuildingElementProxyCommon - Reference: SLRS-200-70-810-760-1750
Type - Pset_ManufacturerTypeInformation - Manufacturer: Lindab
Type - Pset_QuantityTakeOff - Reference: SLRS-200-70-810-760-1750
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Width: 760 mm; Height: 1750 mm; Depth: 760 mm
Group: Mechanické Prívod_ZAR_1 1

# IfcBuildingElementProxy: SLRS 500:SLRS-200-70-810-760-500, SLRS 500:SLRS-200-70-810-760-500:1148440
In: 12NP_STRECHA_VZT
Type - Pset_BuildingElementProxyCommon - Reference: SLRS-200-70-810-760-500
Type - Pset_ManufacturerTypeInformation - Manufacturer: Lindab
Type - Pset_QuantityTakeOff - Reference: SLRS-200-70-810-760-500
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Width: 760 mm; Height: 500 mm; Depth: 760 mm
Group: Mechanické Odvod_ZAR_1 1

# IfcBuildingElementProxy: SLU 600:SLU-200-600-50 (2)
In: 10NP_VZT
Type - Pset_BuildingElementProxyCommon - Reference: SLU-200-600-50
Type - Pset_ManufacturerTypeInformation - Manufacturer: Lindab
Type - Pset_QuantityTakeOff - Reference: SLU-200-600-50
Pset_BuildingElementProxyCommon - sets with these values: 2
Group: Mechanické Odvod_ZAR_3 1
Name (SLU 600:SLU-200-600-50:...)
1093685
1093817

# IfcBuildingElementProxy: Systemair_RVK_200E2-L_sileo_1ph_230V_RFA_2019_LevelBased:RVK 200E2-L sileo 1ph/230V, Systemair_RVK_200E2-L_sileo_1ph_230V_RFA_2019_LevelBased:RVK 200E2-L sileo 1ph/230V:1082233
In: 10NP_VZT
Type - Pset_BuildingElementProxyCommon - Reference: RVK 200E2-L sileo 1ph/230V
Type - Pset_ManufacturerTypeInformation - Manufacturer: Systemair
Type - Pset_QuantityTakeOff - Reference: RVK 200E2-L sileo 1ph/230V
Pset_BuildingElementProxyCommon - sets with these values: 2
Group: Mechanické Odvod_ZAR_3 1

# IfcBuildingElementProxy: WH25M-200:WH25M-200 (2)
In: 10NP_VZT
Type - Pset_BuildingElementProxyCommon - Reference: WH25M-200
Type - Pset_ManufacturerTypeInformation - Manufacturer: Lindab
Type - Pset_QuantityTakeOff - Reference: WH25M-200
Pset_BuildingElementProxyCommon - sets with these values: 2
Group: Mechanické Odvod_ZAR_3 1
Name (WH25M-200:WH25M-200:...)
1064997 | Pset_ProvisionForVoid - Width: 350 mm; Height: 150 mm; Depth: 350 mm
1065223

# IfcBuildingElementProxy: WH45B-U-355:WH45B-U-355 (4)
In: 10NP_VZT
Type - Pset_BuildingElementProxyCommon - Reference: WH45B-U-355
Type - Pset_ManufacturerTypeInformation - Manufacturer: Lindab
Type - Pset_QuantityTakeOff - Reference: WH45B-U-355
Pset_BuildingElementProxyCommon - sets with these values: 2
Name (WH45B-U-355:WH45B-U-355:...) | Group
743605 | Mechanické Prívod_ZAR_2 1 | Pset_ProvisionForVoid - Width: 504 mm; Height: 150 mm; Depth: 504 mm
743928 | Mechanické Prívod_ZAR_2 1
787513 | Mechanické Odvod_ZAR_2 2
791471 | Mechanické Odvod_ZAR_2 2

# IfcBuildingElementProxy: WK25B-500-400:WK25B-500-400 (4)
In: 10NP_VZT
Type - Pset_BuildingElementProxyCommon - Reference: WK25B-500-400
Type - Pset_ManufacturerTypeInformation - Manufacturer: Lindab
Type - Pset_QuantityTakeOff - Reference: WK25B-500-400
Pset_BuildingElementProxyCommon - sets with these values: 2
Name (WK25B-500-400:WK25B-500-400:...) | Group
886810 | Mechanické Odvod_ZAR_1 1 | Pset_ProvisionForVoid - Width: 116 mm; Height: 150 mm; Depth: 116 mm
888309 | Mechanické Odvod_ZAR_1 1
889158 | Mechanické Prívod_ZAR_1 1
889549 | Mechanické Prívod_ZAR_1 1

# IfcBuildingElementProxy: ZAR_1_XP:ZAR_1_XP, ZAR_1_XP:ZAR_1_XP:1121472
In: 12NP_STRECHA_VZT
Type - Pset_BuildingElementProxyCommon - Reference: ZAR_1_XP
Type - Pset_ManufacturerTypeInformation - Manufacturer: REMAK
Type - Pset_QuantityTakeOff - Reference: ZAR_1_XP
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Width: 800 mm; Height: 850 mm; Depth: 800 mm
Group: Mechanické Prívod_ZAR_1 1; Mechanické Odvod_ZAR_1 1

# IfcBuildingElementProxy: ZAR_2_CAKE:ZAR_2_CAKE, ZAR_2_CAKE:ZAR_2_CAKE:945556
In: 12NP_STRECHA_VZT
Type - Pset_BuildingElementProxyCommon - Reference: ZAR_2_CAKE
Type - Pset_ManufacturerTypeInformation - Manufacturer: REMAK
Type - Pset_QuantityTakeOff - Reference: ZAR_2_CAKE
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Width: 50 mm; Height: 56.475 mm; Depth: 50 mm
Group: Mechanické Přiváděný vzduch 3; Mechanické Odvod_ZAR_2 1; Mechanické Prívod_ZAR_2 1; Mechanické Odvod_ZAR_2 2

# IfcCovering: Izolace potrubí:Tepelná izolácia - Exteriér (62)
PredefinedType: INSULATION
Pset_CoveringCommon - Reference: Tepelná izolácia - Exteriér; sets with these values: 2
Name (Izolace potrubí:Tepelná izolácia - Exteriér:...) | In
863850 | 12NP_STRECHA_VZT
863851 | 12NP_STRECHA_VZT
863855 | 11NP_VZT
889077 | 12NP_STRECHA_VZT
909935 | 12NP_STRECHA_VZT
1131861 | 11NP_VZT
1131862 | 12NP_STRECHA_VZT
1131863 | 12NP_STRECHA_VZT
1131864 | 12NP_STRECHA_VZT
1131866 | 12NP_STRECHA_VZT
1137096 | 12NP_STRECHA_VZT
1143070 | 12NP_STRECHA_VZT
1148443 | 12NP_STRECHA_VZT
1148444 | 12NP_STRECHA_VZT
1148798 | 12NP_STRECHA_VZT
1148866 | 12NP_STRECHA_VZT
1148867 | 12NP_STRECHA_VZT
1148870 | 12NP_STRECHA_VZT
1151798 | 11NP_VZT
1151799 | 12NP_STRECHA_VZT
1151800 | 12NP_STRECHA_VZT
1151801 | 12NP_STRECHA_VZT
1151802 | 12NP_STRECHA_VZT
1151803 | 12NP_STRECHA_VZT
1151804 | 12NP_STRECHA_VZT
1151805 | 12NP_STRECHA_VZT
1151806 | 12NP_STRECHA_VZT
1151807 | 12NP_STRECHA_VZT
1151808 | 12NP_STRECHA_VZT
1151809 | 12NP_STRECHA_VZT
1151810 | 12NP_STRECHA_VZT
1151811 | 12NP_STRECHA_VZT
1151812 | 12NP_STRECHA_VZT
1151813 | 12NP_STRECHA_VZT
1151814 | 12NP_STRECHA_VZT
1151815 | 12NP_STRECHA_VZT
1151816 | 12NP_STRECHA_VZT
1151817 | 12NP_STRECHA_VZT
1151818 | 12NP_STRECHA_VZT
1151819 | 12NP_STRECHA_VZT
1151820 | 12NP_STRECHA_VZT
1151834 | 12NP_STRECHA_VZT
1151835 | 12NP_STRECHA_VZT
1151889 | 12NP_STRECHA_VZT
1151913 | 12NP_STRECHA_VZT
1151914 | 12NP_STRECHA_VZT
1151915 | 12NP_STRECHA_VZT
1151916 | 12NP_STRECHA_VZT
1151999 | 12NP_STRECHA_VZT
1152083 | 12NP_STRECHA_VZT
1152084 | 11NP_VZT
1152085 | 12NP_STRECHA_VZT
1152086 | 12NP_STRECHA_VZT
1152087 | 12NP_STRECHA_VZT
1152088 | 12NP_STRECHA_VZT
1152089 | 12NP_STRECHA_VZT
1152090 | 12NP_STRECHA_VZT
1152091 | 12NP_STRECHA_VZT
1152092 | 12NP_STRECHA_VZT
1152093 | 12NP_STRECHA_VZT
1152094 | 12NP_STRECHA_VZT
1152316 | 12NP_STRECHA_VZT

# IfcCovering: Izolace potrubí:Tepelná izolácia - Interiér (132)
PredefinedType: INSULATION
Pset_CoveringCommon - Reference: Tepelná izolácia - Interiér; sets with these values: 2
Name (Izolace potrubí:Tepelná izolácia - Interiér:...) | In
863856 | 10NP_VZT
863857 | 10NP_VZT
863858 | 10NP_VZT
863860 | 10NP_VZT
863861 | 10NP_VZT
863862 | 10NP_VZT
863865 | 10NP_VZT
863866 | 10NP_VZT
863867 | 10NP_VZT
863868 | 10NP_VZT
863869 | 10NP_VZT
863870 | 10NP_VZT
863873 | 10NP_VZT
863874 | 10NP_VZT
863875 | 10NP_VZT
863876 | 10NP_VZT
863877 | 10NP_VZT
863878 | 10NP_VZT
863881 | 10NP_VZT
863882 | 10NP_VZT
863883 | 10NP_VZT
863885 | 10NP_VZT
863886 | 10NP_VZT
863887 | 10NP_VZT
863888 | 10NP_VZT
863889 | 10NP_VZT
863890 | 10NP_VZT
863891 | 10NP_VZT
863895 | 10NP_VZT
863897 | 10NP_VZT
863899 | 10NP_VZT
889509 | 10NP_VZT
889609 | 10NP_VZT
889757 | 10NP_VZT
889833 | 10NP_VZT
889948 | 10NP_VZT
889953 | 10NP_VZT
909026 | 10NP_VZT
909112 | 10NP_VZT
909177 | 10NP_VZT
909258 | 10NP_VZT
909592 | 10NP_VZT
909593 | 10NP_VZT
909594 | 10NP_VZT
909595 | 10NP_VZT
909596 | 10NP_VZT
912092 | 10NP_VZT
912093 | 10NP_VZT
912097 | 10NP_VZT
936375 | 10NP_VZT
936378 | 10NP_VZT
939463 | 10NP_VZT
940696 | 10NP_VZT
940700 | 10NP_VZT
940787 | 10NP_VZT
940788 | 10NP_VZT
940899 | 10NP_VZT
940900 | 10NP_VZT
940989 | 10NP_VZT
940990 | 10NP_VZT
941085 | 10NP_VZT
941086 | 10NP_VZT
941129 | 10NP_VZT
941130 | 10NP_VZT
941339 | 10NP_VZT
941340 | 10NP_VZT
941405 | 10NP_VZT
941406 | 10NP_VZT
1109965 | 10NP_VZT
1152000 | 10NP_VZT
1152001 | 10NP_VZT
1152002 | 10NP_VZT
1152003 | 10NP_VZT
1152004 | 10NP_VZT
1152005 | 10NP_VZT
1152006 | 10NP_VZT
1152007 | 10NP_VZT
1152008 | 10NP_VZT
1152009 | 10NP_VZT
1152010 | 10NP_VZT
1152011 | 10NP_VZT
1152012 | 10NP_VZT
1152013 | 10NP_VZT
1152014 | 10NP_VZT
1152015 | 10NP_VZT
1152016 | 10NP_VZT
1152017 | 10NP_VZT
1152018 | 10NP_VZT
1152019 | 10NP_VZT
1152020 | 10NP_VZT
1152021 | 10NP_VZT
1152022 | 10NP_VZT
1152023 | 10NP_VZT
1152024 | 10NP_VZT
1152025 | 10NP_VZT
1152026 | 10NP_VZT
1152027 | 10NP_VZT
1152028 | 10NP_VZT
1152029 | 10NP_VZT
1152030 | 10NP_VZT
1152031 | 10NP_VZT
1152032 | 10NP_VZT
1152033 | 10NP_VZT
1152034 | 10NP_VZT
1152035 | 10NP_VZT
1152036 | 10NP_VZT
1152037 | 10NP_VZT
1152038 | 10NP_VZT
1152039 | 10NP_VZT
1152040 | 10NP_VZT
1152041 | 10NP_VZT
1152042 | 10NP_VZT
1152043 | 10NP_VZT
1152044 | 10NP_VZT
1152045 | 10NP_VZT
1152046 | 10NP_VZT
1152047 | 10NP_VZT
1152048 | 10NP_VZT
1152049 | 10NP_VZT
1152050 | 10NP_VZT
1152051 | 10NP_VZT
1152052 | 10NP_VZT
1152053 | 10NP_VZT
1152054 | 10NP_VZT
1152055 | 10NP_VZT
1152056 | 10NP_VZT
1152057 | 10NP_VZT
1152058 | 10NP_VZT
1152059 | 10NP_VZT
1152062 | 11NP_VZT
1152063 | 10NP_VZT
1152069 | 12NP_STRECHA_VZT

# IfcDistributionPort (1247)
Description: Flow
Name | FlowDirection | Group
InPort_922842 | SINK | Mechanické Odvod_ZAR_1 8
OutPort_729871 | SOURCE | Mechanické Odvod_ZAR_1 8
InPort_922838 | SINK | Mechanické Odvod_ZAR_1 7
OutPort_729872 | SOURCE | Mechanické Odvod_ZAR_1 7
InPort_922846 | SINK | Mechanické Odvod_ZAR_1 9
OutPort_729873 | SOURCE | Mechanické Odvod_ZAR_1 9
InPort_922826 | SINK | Mechanické Odvod_ZAR_1 4
OutPort_729874 | SOURCE | Mechanické Odvod_ZAR_1 4
InPort_922830 | SINK | Mechanické Odvod_ZAR_1 5
OutPort_729875 | SOURCE | Mechanické Odvod_ZAR_1 5
InPort_922822 | SINK | Mechanické Odvod_ZAR_1 3
OutPort_729876 | SOURCE | Mechanické Odvod_ZAR_1 3
InPort_921695 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_729877 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_922834 | SINK | Mechanické Odvod_ZAR_1 6
OutPort_729878 | SOURCE | Mechanické Odvod_ZAR_1 6
InPort_921317 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_729916 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_729916 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_922838 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_729920 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_729926 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_921546 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_729920 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_729926 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_729924 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_729924 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_922846 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_921397 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_729928 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_729928 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_922842 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_922625 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_729986 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_729986 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_922830 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_729990 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_729994 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_922679 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_729990 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_729992 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_922822 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_729994 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_729992 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_729996 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_922826 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_922587 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_729996 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_741978 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_730036 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_730036 | SINK | Mechanické Prívod_ZAR_2 1
2 x OutPort_741750 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_738046 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_741778 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_738092 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_749242 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_738253 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_743605 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_802518 | SINK | Mechanické Prívod_ZAR_2 1
2 x OutPort_738253 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_750249 | SINK | Mechanické Prívod_ZAR_2 1
InPort_738311 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_790796 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_738323 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_738311 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_788012 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_738323 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_743928 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_738326 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_738326 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_851639 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_738684 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_851259 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_851639 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_738684 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_791726 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_738952 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_738952 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_745111 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_741543 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_741575 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_755338 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_741543 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_741575 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_741725 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_741579 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_741612 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_741724 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_741579 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_746304 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_741604 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_741604 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_741976 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_741612 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_746306 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_741616 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_741978 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_741976 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_741616 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_755358 | SINK | Mechanické Prívod_ZAR_2 1
2 x OutPort_741724 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_741725 | SINK | Mechanické Prívod_ZAR_2 1
InPort_741750 | SINK | Mechanické Prívod_ZAR_2 1
2 x OutPort_741751 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_741778 | SINK | Mechanické Prívod_ZAR_2 1
InPort_783971 | SINK | Mechanické Prívod_ZAR_2 1
InPort_741751 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_783930 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_743605 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_788012 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_790784 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_743928 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_745111 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_745113 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_745113 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_803873 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_745139 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_749971 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_745141 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_745139 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_791753 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_745141 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_746306 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_746304 | SOURCE | Mechanické Prívod_ZAR_2 1
3 x InPort_747246 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_751222 | SOURCE | Mechanické Odvod_ZAR_2 2
OutPort_804468 | SOURCE | Mechanické Odvod_ZAR_2 2
OutPort_804608 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_787513 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_747246 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_747324 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_787601 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_790681 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_747324 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_785876 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_747938 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_747938 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_792002 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_751222 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_748253 | SOURCE | Mechanické Odvod_ZAR_2 2
3 x InPort_748253 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_751567 | SOURCE | Mechanické Odvod_ZAR_2 2
OutPort_804364 | SOURCE | Mechanické Odvod_ZAR_2 2
OutPort_922494 | SOURCE | Mechanické Odvod_ZAR_2 2
3 x InPort_748513 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_751544 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_751564 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_748513 | SOURCE | Mechanické Odvod_ZAR_2 2
OutPort_922742 | SOURCE | Mechanické Odvod_ZAR_2 2
OutPort_921551 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_751544 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_748522 | SOURCE | Mechanické Odvod_ZAR_2 2
2 x InPort_748522 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_921618 | SOURCE | Mechanické Odvod_ZAR_2 2
OutPort_939223 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_749242 | SINK | Mechanické Prívod_ZAR_2 1
3 x OutPort_750249 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_749971 | SINK | Mechanické Prívod_ZAR_2 1
InPort_750990 | SINK | Mechanické Prívod_ZAR_2 1
InPort_750253 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_750990 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_803873 | SINK | Mechanické Prívod_ZAR_2 1
2 x OutPort_750253 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_783930 | SINK | Mechanické Prívod_ZAR_2 1
InPort_803188 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_750440 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_750440 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_789857 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_937677 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_750532 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_750532 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_792105 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_921615 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_751424 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_751424 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_921695 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_751432 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_929185 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_921618 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_751432 | SOURCE | Mechanické Odvod_ZAR_2 2
2 x InPort_751548 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_751564 | SOURCE | Mechanické Odvod_ZAR_2 2
OutPort_922684 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_751567 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_751548 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_753129 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_752778 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_752778 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_784685 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_752947 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_804602 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_804608 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_752947 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_753117 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_753129 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_786650 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_753117 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_753200 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_937677 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_937682 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_753200 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_804468 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_753204 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_753204 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_804462 | SOURCE | Mechanické Odvod_ZAR_2 2
2 x InPort_753210 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_803188 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_804462 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_753210 | SOURCE | Mechanické Odvod_ZAR_2 2
OutPort_937643 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_755279 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_755338 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_755354 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_755358 | SOURCE | Mechanické Prívod_ZAR_2 1
2 x Port_766715 | SOURCEANDSINK | Teplovodní přívod 1
Port_781229 | SINK
3 x Port_781229 | SOURCEANDSINK
Port_781229 | SOURCE
2 x InPort_938813 | SINK | Mechanické Odvod_ZAR_2 3
OutPort_782976 | SOURCE | Mechanické Odvod_ZAR_2 3
InPort_938864 | SINK | Mechanické Odvod_ZAR_2 3
OutPort_783163 | SOURCE | Mechanické Odvod_ZAR_2 3
InPort_783832 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_783834 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_783856 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_783832 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_783834 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_783845 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_783844 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_783836 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_783836 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_783840 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_783852 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_783838 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_783838 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_783971 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_783840 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_783853 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_783845 | SINK | Mechanické Prívod_ZAR_2 1
2 x OutPort_783844 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_783859 | SINK | Mechanické Prívod_ZAR_2 1
InPort_783853 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_783852 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_783855 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_783856 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_783858 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_783859 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_783996 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_783998 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_784014 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_783996 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_783998 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_784007 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_784006 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_784000 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_784000 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_784004 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_784002 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_802518 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_784010 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_784002 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_784004 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_784946 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_784007 | SINK | Mechanické Prívod_ZAR_2 1
2 x OutPort_784006 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_784017 | SINK | Mechanické Prívod_ZAR_2 1
InPort_784929 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_784010 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_784013 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_784014 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_784016 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_784017 | SOURCE | Mechanické Prívod_ZAR_2 1
2 x InPort_784641 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_784683 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_784685 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_784641 | SOURCE | Mechanické Odvod_ZAR_2 2
OutPort_785116 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_784643 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_784649 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_785116 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_784643 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_784649 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_784647 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_784651 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_784648 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_784647 | SINK | Mechanické Odváděný vzduch 2
OutPort_784649 | SOURCE | Mechanické Odváděný vzduch 2
InPort_784683 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_784651 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_784648 | SINK | Mechanické Odváděný vzduch 2
OutPort_784651 | SOURCE | Mechanické Odváděný vzduch 2
InPort_784943 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_784929 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_784956 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_784937 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_784937 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_784943 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_784946 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_784956 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_939015 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_785619 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_785619 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_785876 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_785622 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_939001 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_789859 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_785622 | SOURCE | Mechanické Odvod_ZAR_2 2
Port_786421 | SINK
3 x Port_786421 | SOURCEANDSINK
Port_786421 | SOURCE
InPort_786652 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_786650 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_804602 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_786652 | SOURCE | Mechanické Odvod_ZAR_2 2
2 x InPort_938624 | SINK | Mechanické Odvod_ZAR_2 3
OutPort_787176 | SOURCE | Mechanické Odvod_ZAR_2 3
InPort_787234 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_787176 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_939223 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_787234 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_787601 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_787513 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_789191 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_928229 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_922742 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_789191 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_789599 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_922912 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_921551 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_789599 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_922684 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_789683 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_789683 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_923073 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_789857 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_789859 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_790524 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_928367 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_922494 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_790524 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_790756 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_790681 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_791473 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_790756 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_790796 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_790784 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_851614 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_790830 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_790830 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_791471 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_851400 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_790840 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_790840 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_851614 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_791471 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_791473 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_791684 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_791726 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_791740 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_791753 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_792002 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_791894 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_791894 | SINK | Mechanické Odváděný vzduch 2
OutPort_792002 | SOURCE | Mechanické Odváděný vzduch 2
InPort_792105 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_792062 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_792062 | SINK | Mechanické Odváděný vzduch 2
OutPort_792105 | SOURCE | Mechanické Odváděný vzduch 2
Port_792151 | SINK
3 x Port_792151 | SOURCEANDSINK
Port_792151 | SOURCE
3 x Port_792335 | SOURCEANDSINK
Port_792335 | SINK
Port_792335 | SOURCE
InPort_817366 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_792602 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_792602 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_792606 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_792606 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_840280 | SOURCE | Mechanické Odvod_ZAR_1 1
2 x InPort_817453 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_792608 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_792608 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_840313 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_838984 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_793122 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_793122 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_793126 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_793126 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_793127 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_793127 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_889946 | SOURCE | Mechanické Prívod_ZAR_1 1
3 x Port_796492 | SOURCEANDSINK
Port_796492 | SOURCE
Port_796492 | SINK
3 x Port_797577 | SOURCEANDSINK
Port_797577 | SINK
Port_797577 | SOURCE
Port_798988 | SOURCE | Mechanické Přiváděný vzduch 1
Port_799069 | SOURCE | Mechanické Přiváděný vzduch 1
2 x Port_799087 | SOURCEANDSINK | Mechanické Přiváděný vzduch 2
Port_799421 | SOURCE | Mechanické Přiváděný vzduch 5
Port_799422 | SOURCE | Mechanické Přiváděný vzduch 4
2 x Port_799423 | SOURCEANDSINK | Mechanické Přiváděný vzduch 6
Port_799651 | SOURCE | Mechanické Přiváděný vzduch 7
Port_799652 | SOURCE | Mechanické Přiváděný vzduch 7
2 x Port_799653 | SOURCEANDSINK | Mechanické Přiváděný vzduch 9
Port_799664 | SOURCE | Mechanické Přiváděný vzduch 8
Port_799665 | SOURCE | Mechanické Přiváděný vzduch 8
2 x Port_799666 | SOURCEANDSINK | Mechanické Přiváděný vzduch 10
Port_801129 | SOURCE | Mechanické Přiváděný vzduch 11
Port_801212 | SOURCE | Mechanické Přiváděný vzduch 11
2 x Port_801223 | SOURCEANDSINK | Mechanické Přiváděný vzduch 25
Port_801260 | SOURCE | Mechanické Přiváděný vzduch 12
Port_801261 | SOURCE | Mechanické Přiváděný vzduch 12
2 x Port_801262 | SOURCEANDSINK | Mechanické Přiváděný vzduch 26
Port_801308 | SOURCE | Mechanické Přiváděný vzduch 13
Port_801309 | SOURCE | Mechanické Přiváděný vzduch 13
2 x Port_801310 | SOURCEANDSINK | Mechanické Přiváděný vzduch 27
Port_801330 | SOURCE | Mechanické Přiváděný vzduch 14
Port_801331 | SOURCE | Mechanické Přiváděný vzduch 14
2 x Port_801332 | SOURCEANDSINK | Mechanické Přiváděný vzduch 28
Port_801351 | SOURCE | Mechanické Přiváděný vzduch 15
Port_801352 | SOURCE | Mechanické Přiváděný vzduch 15
2 x Port_801353 | SOURCEANDSINK | Mechanické Přiváděný vzduch 29
Port_801401 | SOURCE | Mechanické Přiváděný vzduch 16
Port_801402 | SOURCE | Mechanické Přiváděný vzduch 16
2 x Port_801403 | SOURCEANDSINK | Mechanické Přiváděný vzduch 30
Port_801414 | SOURCE | Mechanické Přiváděný vzduch 17
Port_801415 | SOURCE | Mechanické Přiváděný vzduch 17
2 x Port_801416 | SOURCEANDSINK | Mechanické Přiváděný vzduch 31
Port_801427 | SOURCE | Mechanické Přiváděný vzduch 18
Port_801428 | SOURCE | Mechanické Přiváděný vzduch 18
2 x Port_801429 | SOURCEANDSINK | Mechanické Přiváděný vzduch 32
Port_801440 | SOURCE | Mechanické Přiváděný vzduch 19
Port_801441 | SOURCE | Mechanické Přiváděný vzduch 19
2 x Port_801442 | SOURCEANDSINK | Mechanické Přiváděný vzduch 33
Port_801453 | SOURCE | Mechanické Přiváděný vzduch 20
Port_801454 | SOURCE | Mechanické Přiváděný vzduch 20
2 x Port_801455 | SOURCEANDSINK | Mechanické Přiváděný vzduch 34
Port_801466 | SOURCE | Mechanické Přiváděný vzduch 21
Port_801467 | SOURCE | Mechanické Přiváděný vzduch 21
2 x Port_801468 | SOURCEANDSINK | Mechanické Přiváděný vzduch 35
Port_801483 | SOURCE | Mechanické Přiváděný vzduch 22
Port_801484 | SOURCE | Mechanické Přiváděný vzduch 22
Port_801498 | SOURCE | Mechanické Přiváděný vzduch 23
Port_801499 | SOURCE | Mechanické Přiváděný vzduch 23
2 x Port_801500 | SOURCEANDSINK | Mechanické Přiváděný vzduch 37
Port_801513 | SOURCE | Mechanické Přiváděný vzduch 24
Port_801514 | SOURCE | Mechanické Přiváděný vzduch 24
2 x Port_801515 | SOURCEANDSINK | Mechanické Přiváděný vzduch 38
2 x Port_801627 | SOURCEANDSINK | Mechanické Přiváděný vzduch 36
3 x Port_802101 | SOURCEANDSINK
Port_802101 | SOURCE
Port_802101 | SINK
InPort_803358 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_803352 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_803352 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_803372 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_804364 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_803354 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_803354 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_804358 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_803376 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_803356 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_803356 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_803358 | SOURCE | Mechanické Odvod_ZAR_2 2
2 x InPort_803360 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_803605 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_803372 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_803360 | SOURCE | Mechanické Odvod_ZAR_2 2
OutPort_803370 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_803362 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_803366 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_803605 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_803362 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_803366 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_803364 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_803368 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_803365 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_803364 | SINK | Mechanické Odváděný vzduch 2
OutPort_803366 | SOURCE | Mechanické Odváděný vzduch 2
InPort_803370 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_803368 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_803365 | SINK | Mechanické Odváděný vzduch 2
OutPort_803368 | SOURCE | Mechanické Odváděný vzduch 2
InPort_803377 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_803376 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_804358 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_803377 | SOURCE | Mechanické Odvod_ZAR_2 2
Port_806247 | SINK
3 x Port_806247 | SOURCEANDSINK
Port_806247 | SOURCE
Port_806359 | SOURCE
3 x Port_806359 | SOURCEANDSINK
Port_806359 | SINK
Port_806367 | SINK
3 x Port_806367 | SOURCEANDSINK
Port_806367 | SOURCE
InPort_807910 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_889510 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_889508 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_807910 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_887350 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_809895 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_809895 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_887376 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_887436 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_810311 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_810311 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_887429 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_812608 | SINK | Mechanické Prívod_ZAR_1 1
4 x OutPort_810663 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_889951 | SINK | Mechanické Prívod_ZAR_1 1
InPort_812715 | SINK | Mechanické Prívod_ZAR_1 1
InPort_909024 | SINK | Mechanické Prívod_ZAR_1 1
InPort_810663 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_889832 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_887429 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_811344 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_811344 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_811367 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_811367 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_811417 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_811417 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_811431 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_819475 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_811425 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_811425 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_840506 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_811431 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_819507 | SOURCE | Mechanické Odvod_ZAR_1 1
4 x InPort_811768 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_887436 | SOURCE | Mechanické Odvod_ZAR_1 1
OutPort_887488 | SOURCE | Mechanické Odvod_ZAR_1 1
OutPort_815656 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_887376 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_811768 | SOURCE | Mechanické Odvod_ZAR_1 1
OutPort_909304 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_887488 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_812113 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_812113 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_887483 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_820657 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_812124 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_812124 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_812143 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_812143 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_840722 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_838640 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_812600 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_812600 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_940650 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_940694 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_812608 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_812707 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_940737 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_1110515 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_812707 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_940785 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_812715 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_812746 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_909024 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_909110 | SINK | Mechanické Prívod_ZAR_1 1
3 x OutPort_812746 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_813366 | SINK | Mechanické Prívod_ZAR_1 1
InPort_813333 | SINK | Mechanické Prívod_ZAR_1 1
InPort_838643 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_812942 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_812942 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_940875 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_812944 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_940943 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_838646 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_812944 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_940987 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_813333 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_940897 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_813366 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_813434 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_909110 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_909175 | SINK | Mechanické Prívod_ZAR_1 1
2 x OutPort_813434 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_813586 | SINK | Mechanické Prívod_ZAR_1 1
InPort_813434 | SOURCEANDSINK | Mechanické Prívod_ZAR_1 1
2 x OutPort_909256 | SOURCEANDSINK | Mechanické Prívod_ZAR_1 1
2 x InPort_813496 | SOURCEANDSINK | Mechanické Prívod_ZAR_1 1
OutPort_941059 | SOURCEANDSINK | Mechanické Prívod_ZAR_1 1
InPort_813498 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_941107 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_838649 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_813498 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_941127 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_813586 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_1109964 | SINK | Mechanické Prívod_ZAR_1 1
3 x OutPort_814087 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_814847 | SINK | Mechanické Prívod_ZAR_1 1
InPort_814845 | SINK | Mechanické Prívod_ZAR_1 1
InPort_814087 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_909175 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_838655 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_814608 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_814608 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_941373 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_814610 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_941315 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_838658 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_814610 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_941337 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_814845 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_941403 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_814847 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_814919 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_814921 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_839473 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_814919 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_814921 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_814926 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_814923 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_1109964 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_936317 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_814923 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_814926 | SINK | Mechanické Prívod_ZAR_1 1
2 x OutPort_814925 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_814925 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_936373 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_890663 | SINK | Mechanické Prívod_ZAR_1 1
InPort_815602 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_815652 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_815656 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_815602 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_815604 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_815608 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_820824 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_815604 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_815608 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_840872 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_815652 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_820864 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_909304 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_815741 | SOURCE | Mechanické Odvod_ZAR_1 1
2 x InPort_815741 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_816191 | SOURCE | Mechanické Odvod_ZAR_1 1
OutPort_1103801 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_816130 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_816187 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_816191 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_816130 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_821102 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_816132 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_816132 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_816134 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_816134 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_840882 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_816187 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_821104 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_816970 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_821159 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_1103808 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_816970 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_817111 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_840890 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_821185 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_817111 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_817454 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_817366 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_819309 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_817453 | SOURCE | Mechanické Odvod_ZAR_1 1
OutPort_817454 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_1103801 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_817727 | SOURCE | Mechanické Odvod_ZAR_1 1
2 x InPort_817727 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_1103803 | SOURCE | Mechanické Odvod_ZAR_1 1
OutPort_1103808 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_818860 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_818166 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_818166 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_819267 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_822389 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_818860 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_819267 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_819309 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_819507 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_819475 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_820729 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_820657 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_887483 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_820729 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_820864 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_820824 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_821104 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_821102 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_821159 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_821185 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_822556 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_822389 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_1103803 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_822547 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_822547 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_822556 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_824520 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_912090 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_889832 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_824520 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_889946 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_824658 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_824658 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_889951 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_851256 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_836827 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_836827 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_1149896 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_838238 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_1110515 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_838475 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_838640 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_838483 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_838652 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_838491 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_838649 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_838499 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_838658 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_838507 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_838655 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_838519 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_838643 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_838527 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_838646 | SOURCE | Mechanické Prívod_ZAR_1 1
Port_838652 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_838960 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_838984 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_839266 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_890663 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_839430 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_839473 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_922818 | SINK | Mechanické Odvod_ZAR_1 2
OutPort_839801 | SOURCE | Mechanické Odvod_ZAR_1 2
InPort_840506 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_840149 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_1048794 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_841109 | SOURCE | Mechanické Odvod_ZAR_3 1
InPort_1048421 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_841353 | SOURCE | Mechanické Odvod_ZAR_3 1
InPort_1097301 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_841392 | SOURCE | Mechanické Odvod_ZAR_3 1
InPort_1048323 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_841468 | SOURCE | Mechanické Odvod_ZAR_3 1
InPort_1048327 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_841521 | SOURCE | Mechanické Odvod_ZAR_3 1
InPort_1048765 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_841677 | SOURCE | Mechanické Odvod_ZAR_3 1
InPort_1048769 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_841724 | SOURCE | Mechanické Odvod_ZAR_3 1
InPort_1048761 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_841757 | SOURCE | Mechanické Odvod_ZAR_3 1
InPort_850248 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_909774 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_850267 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_850248 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_850262 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_850267 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_857452 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_850262 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_863690 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_850351 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_850351 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_889075 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_851259 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_851256 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_851397 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_851400 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_1150096 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_851397 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_1148791 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_857452 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_889135 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_863689 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_863689 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_863690 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_889075 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_870526 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_870526 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_1137095 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_884902 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_887350 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_886810 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_884902 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_886914 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_886810 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_888309 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_886914 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_888391 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_888309 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_909811 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_888391 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_889510 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_889126 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_889126 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_889158 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_889278 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_889135 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_889158 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_889278 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_889607 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_889508 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_889549 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_889607 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_889750 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_889549 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_912096 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_889750 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_909774 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_909799 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_909799 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_909811 | SOURCE | Mechanické Odvod_ZAR_1 1
2 x InPort_1121472 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_909940 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_909940 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_1148440 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_912090 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_912082 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_912082 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_912096 | SOURCE | Mechanické Prívod_ZAR_1 1
3 x InPort_922960 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_921317 | SOURCE | Mechanické Odvod_ZAR_2 2
OutPort_921397 | SOURCE | Mechanické Odvod_ZAR_2 2
OutPort_921546 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_929223 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_921615 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_729877 | SINK | Mechanické Odváděný vzduch 2
OutPort_921695 | SOURCE | Mechanické Odváděný vzduch 2
3 x InPort_923089 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_922587 | SOURCE | Mechanické Odvod_ZAR_2 2
OutPort_922625 | SOURCE | Mechanické Odvod_ZAR_2 2
OutPort_922679 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_928397 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_922818 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_839801 | SINK | Mechanické Odváděný vzduch 2
OutPort_922818 | SOURCE | Mechanické Odváděný vzduch 2
InPort_729876 | SINK | Mechanické Odváděný vzduch 2
OutPort_922822 | SOURCE | Mechanické Odváděný vzduch 2
InPort_729874 | SINK | Mechanické Odváděný vzduch 2
