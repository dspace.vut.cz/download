Properties of the parts of a building model (IFC2X3), part 2 of 2

# IfcDistributionPort (1247)
Name | FlowDirection | Group
OutPort_922826 | SOURCE | Mechanické Odváděný vzduch 2
InPort_729875 | SINK | Mechanické Odváděný vzduch 2
OutPort_922830 | SOURCE | Mechanické Odváděný vzduch 2
InPort_928255 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_922834 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_729878 | SINK | Mechanické Odváděný vzduch 2
OutPort_922834 | SOURCE | Mechanické Odváděný vzduch 2
InPort_729872 | SINK | Mechanické Odváděný vzduch 2
OutPort_922838 | SOURCE | Mechanické Odváděný vzduch 2
InPort_729871 | SINK | Mechanické Odváděný vzduch 2
OutPort_922842 | SOURCE | Mechanické Odváděný vzduch 2
InPort_729873 | SINK | Mechanické Odváděný vzduch 2
OutPort_922846 | SOURCE | Mechanické Odváděný vzduch 2
InPort_922912 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_922960 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_923073 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_923089 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_928229 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_928255 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_928367 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_928397 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_929185 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_929223 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_936373 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_936317 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_937633 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_937682 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_938109 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_937633 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_937643 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_938155 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_938155 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_938109 | SOURCE | Mechanické Odvod_ZAR_2 2
OutPort_938867 | SOURCE | Mechanické Odvod_ZAR_2 3
InPort_938784 | SINK | Mechanické Odvod_ZAR_2 3
OutPort_938624 | SOURCE | Mechanické Odvod_ZAR_2 3
OutPort_938773 | SOURCE | Mechanické Odvod_ZAR_2 3
InPort_938773 | SINK | Mechanické Odvod_ZAR_2 3
OutPort_938784 | SOURCE | Mechanické Odvod_ZAR_2 3
InPort_782976 | SINK | Mechanické Odváděný vzduch 2
OutPort_938813 | SOURCE | Mechanické Odváděný vzduch 2
InPort_938867 | SINK | Mechanické Odvod_ZAR_2 3
OutPort_938864 | SOURCE | Mechanické Odvod_ZAR_2 3
InPort_783163 | SINK | Mechanické Odváděný vzduch 2
OutPort_938864 | SOURCE | Mechanické Odváděný vzduch 2
InPort_939001 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_939015 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_940650 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_940694 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_940737 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_940785 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_940875 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_940897 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_940943 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_940987 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_941059 | SOURCEANDSINK | Mechanické Prívod_ZAR_1 1
OutPort_941083 | SOURCEANDSINK | Mechanické Prívod_ZAR_1 1
Port_941083 | SOURCEANDSINK | Mechanické Prívod_ZAR_1 1
InPort_941107 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_941127 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_941315 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_941337 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_941373 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_941403 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_945556 | SINK | Mechanické Odvod_ZAR_2 1
OutPort_952335 | SOURCE | Mechanické Odvod_ZAR_2 1
InPort_945556 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_952148 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_951895 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_945556 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_952420 | SINK | Mechanické Přiváděný vzduch 3
OutPort_945556 | SOURCE | Mechanické Přiváděný vzduch 3
InPort_1105515 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_951342 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_951342 | SINK | Mechanické Prívod_ZAR_1 1
2 x OutPort_1121472 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_951422 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_1121472 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_1131828 | SINK | Mechanické Odvod_ZAR_1 1
2 x OutPort_951422 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_1105544 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_951432 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_951432 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_1131828 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_1149901 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_951794 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_951794 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_951813 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_951813 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_951860 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_951860 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_951874 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_951874 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_951868 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_951868 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_952049 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_952049 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_951895 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_952148 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_952162 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_952162 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_952216 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_952216 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_952233 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_952233 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_952225 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_952225 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_1149851 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_952335 | SINK | Mechanické Odvod_ZAR_2 1
OutPort_1151325 | SOURCE | Mechanické Odvod_ZAR_2 1
InPort_1151236 | SINK | Mechanické Přiváděný vzduch 3
OutPort_952420 | SOURCE | Mechanické Přiváděný vzduch 3
2 x Port_1030875 | SINK
3 x Port_1030875 | SOURCEANDSINK
InPort_1097512 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_1047004 | SOURCE | Mechanické Odvod_ZAR_3 1
InPort_1047004 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_1097818 | SOURCE | Mechanické Odvod_ZAR_3 1
2 x InPort_1047280 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_1082408 | SOURCE | Mechanické Odvod_ZAR_3 1
InPort_1096887 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_1047280 | SOURCE | Mechanické Odvod_ZAR_3 1
OutPort_1048433 | SOURCE | Mechanické Odvod_ZAR_3 1
InPort_1151963 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_1047542 | SOURCE | Mechanické Odvod_ZAR_3 1
InPort_1047542 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_1047567 | SOURCE | Mechanické Odvod_ZAR_3 1
InPort_1047567 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_1047558 | SOURCE | Mechanické Odvod_ZAR_3 1
InPort_1047558 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_1106538 | SOURCE | Mechanické Odvod_ZAR_3 1
InPort_1048452 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_1048161 | SOURCE | Mechanické Odvod_ZAR_3 1
InPort_1048290 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_1048284 | SOURCE | Mechanické Odvod_ZAR_3 1
InPort_1048284 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_1048327 | SOURCE | Mechanické Odvod_ZAR_3 1
2 x InPort_1054116 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_1048290 | SOURCE | Mechanické Odvod_ZAR_3 1
InPort_1048303 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_1048323 | SOURCE | Mechanické Odvod_ZAR_3 1
InPort_1097475 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_1048303 | SOURCE | Mechanické Odvod_ZAR_3 1
InPort_1097412 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_1048389 | SOURCE | Mechanické Odvod_ZAR_3 1
InPort_1048389 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_1048956 | SOURCE | Mechanické Odvod_ZAR_3 1
InPort_1048956 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_1048397 | SOURCE | Mechanické Odvod_ZAR_3 1
InPort_1048397 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_1048421 | SOURCE | Mechanické Odvod_ZAR_3 1
InPort_1048425 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_1048452 | SOURCE | Mechanické Odvod_ZAR_3 1
InPort_1053497 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_1048425 | SOURCE | Mechanické Odvod_ZAR_3 1
InPort_1048433 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_1053533 | SOURCE | Mechanické Odvod_ZAR_3 1
InPort_1048718 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_1048510 | SOURCE | Mechanické Odvod_ZAR_3 1
InPort_1048510 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_1053961 | SOURCE | Mechanické Odvod_ZAR_3 1
InPort_1048516 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_1048514 | SOURCE | Mechanické Odvod_ZAR_3 1
InPort_1048514 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_1048765 | SOURCE | Mechanické Odvod_ZAR_3 1
3 x InPort_1053985 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_1048516 | SOURCE | Mechanické Odvod_ZAR_3 1
InPort_1048520 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_1048518 | SOURCE | Mechanické Odvod_ZAR_3 1
InPort_1048518 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_1048769 | SOURCE | Mechanické Odvod_ZAR_3 1
OutPort_1048520 | SOURCE | Mechanické Odvod_ZAR_3 1
3 x InPort_1063936 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_1048718 | SOURCE | Mechanické Odvod_ZAR_3 1
InPort_1048731 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_1048748 | SOURCE | Mechanické Odvod_ZAR_3 1
InPort_1048739 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_1048731 | SOURCE | Mechanické Odvod_ZAR_3 1
OutPort_1048739 | SOURCE | Mechanické Odvod_ZAR_3 1
InPort_1048748 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_1048742 | SOURCE | Mechanické Odvod_ZAR_3 1
InPort_1048742 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_1048761 | SOURCE | Mechanické Odvod_ZAR_3 1
InPort_1048773 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_1048794 | SOURCE | Mechanické Odvod_ZAR_3 1
InPort_1053367 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_1048773 | SOURCE | Mechanické Odvod_ZAR_3 1
InPort_1048783 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_1053389 | SOURCE | Mechanické Odvod_ZAR_3 1
OutPort_1048783 | SOURCE | Mechanické Odvod_ZAR_3 1
InPort_1053389 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_1053367 | SOURCE | Mechanické Odvod_ZAR_3 1
InPort_1053533 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_1053497 | SOURCE | Mechanické Odvod_ZAR_3 1
InPort_1053961 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_1053985 | SOURCE | Mechanické Odvod_ZAR_3 1
InPort_1097409 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_1054116 | SOURCE | Mechanické Odvod_ZAR_3 1
OutPort_1097412 | SOURCE | Mechanické Odvod_ZAR_3 1
InPort_1082408 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_1063936 | SOURCE | Mechanické Odvod_ZAR_3 1
OutPort_1064997 | SOURCE | Mechanické Odvod_ZAR_3 1
InPort_1064000 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_1151961 | SOURCE | Mechanické Odvod_ZAR_3 1
InPort_1065265 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_1064000 | SOURCE | Mechanické Odvod_ZAR_3 1
InPort_1064997 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_1082118 | SOURCE | Mechanické Odvod_ZAR_3 1
InPort_1082259 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_1065223 | SOURCE | Mechanické Odvod_ZAR_3 1
InPort_1065223 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_1065265 | SOURCE | Mechanické Odvod_ZAR_3 1
InPort_1082118 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_1093685 | SOURCE | Mechanické Odvod_ZAR_3 1
InPort_1082233 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_1093819 | SOURCE | Mechanické Odvod_ZAR_3 1
InPort_1093719 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_1082233 | SOURCE | Mechanické Odvod_ZAR_3 1
InPort_1093817 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_1082259 | SOURCE | Mechanické Odvod_ZAR_3 1
InPort_1093685 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_1093719 | SOURCE | Mechanické Odvod_ZAR_3 1
InPort_1093819 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_1093817 | SOURCE | Mechanické Odvod_ZAR_3 1
InPort_1096863 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_1096887 | SOURCE | Mechanické Odvod_ZAR_3 1
InPort_1097560 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_1096863 | SOURCE | Mechanické Odvod_ZAR_3 1
InPort_1097834 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_1097301 | SOURCE | Mechanické Odvod_ZAR_3 1
4 x InPort_1097600 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_1097409 | SOURCE | Mechanické Odvod_ZAR_3 1
OutPort_1097475 | SOURCE | Mechanické Odvod_ZAR_3 1
OutPort_1097512 | SOURCE | Mechanické Odvod_ZAR_3 1
OutPort_1097560 | SOURCE | Mechanické Odvod_ZAR_3 1
InPort_1097818 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_1097834 | SOURCE | Mechanické Odvod_ZAR_3 1
6 x Port_1121472 | SINK
2 x Port_1121472 | SOURCE
InPort_1137017 | SINK | Mechanické Prívod_ZAR_1 1
InPort_1143067 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_1137017 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_1137095 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_1143069 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_1143069 | SINK | Mechanické Prívod_ZAR_1 1
OutPort_1143067 | SOURCE | Mechanické Prívod_ZAR_1 1
InPort_1148440 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_1148442 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_1148442 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_1148868 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_1148865 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_1148791 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_1148868 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_1148799 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_1148799 | SINK | Mechanické Odvod_ZAR_1 1
OutPort_1148865 | SOURCE | Mechanické Odvod_ZAR_1 1
InPort_1149851 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_1149994 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_1149982 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_1149870 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_1149870 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_1150024 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_1149894 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_1149901 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_1149899 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_1149894 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_1149896 | SINK | Mechanické Prívod_ZAR_2 1
OutPort_1149899 | SOURCE | Mechanické Prívod_ZAR_2 1
InPort_1150011 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_1149967 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_1149967 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_1149982 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_1149994 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_1150011 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_1150024 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_1150102 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_1150088 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_1150096 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_1150111 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_1150088 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_1150102 | SINK | Mechanické Odvod_ZAR_2 2
OutPort_1150111 | SOURCE | Mechanické Odvod_ZAR_2 2
InPort_1151329 | SINK | Mechanické Odvod_ZAR_2 1
OutPort_1151106 | SOURCE | Mechanické Odvod_ZAR_2 1
2 x InPort_1151240 | SINK | Mechanické Přiváděný vzduch 3
OutPort_1151123 | SOURCE | Mechanické Přiváděný vzduch 3
InPort_1151256 | SINK | Mechanické Přiváděný vzduch 3
OutPort_1151228 | SOURCE | Mechanické Přiváděný vzduch 3
InPort_1151228 | SINK | Mechanické Přiváděný vzduch 3
OutPort_1151236 | SOURCE | Mechanické Přiváděný vzduch 3
InPort_1151123 | SINK | Mechanické Přiváděný vzduch 3
OutPort_1151240 | SOURCE | Mechanické Přiváděný vzduch 3
OutPort_1151256 | SOURCE | Mechanické Přiváděný vzduch 3
InPort_1151319 | SINK | Mechanické Odvod_ZAR_2 1
OutPort_1151341 | SOURCE | Mechanické Odvod_ZAR_2 1
InPort_1151325 | SINK | Mechanické Odvod_ZAR_2 1
OutPort_1151319 | SOURCE | Mechanické Odvod_ZAR_2 1
InPort_1151341 | SINK | Mechanické Odvod_ZAR_2 1
OutPort_1151329 | SOURCE | Mechanické Odvod_ZAR_2 1
InPort_1151961 | SINK | Mechanické Odvod_ZAR_3 1
OutPort_1151963 | SOURCE | Mechanické Odvod_ZAR_3 1

# IfcEnergyConversionDevice: Fujitsu General_ASYG18LFCA:ASYG18LFCA, Fujitsu General_ASYG18LFCA:ASYG18LFCA:1030875
In: 1013
Type - PredefinedType: AIRCONDITIONINGUNIT; Material: Color RGB 216-216-216
Type - Pset_DistributionFlowElementCommon - Reference: ASYG18LFCA
Type - Pset_ManufacturerTypeInformation - Manufacturer: FUJITSU GENERAL LIMITED
Type - Pset_QuantityTakeOff - Reference: ASYG18LFCA
Pset_DistributionFlowElementCommon - sets with these values: 2

# IfcEnergyConversionDevice: HC_Air Conditioner_Indoor Unit_MEPcontent_Mitsubishi Heavy Industries_PAC_FDTC40-60VH_INT-EN:FDTC40VH (6)
Type - PredefinedType: AIRCONDITIONINGUNIT; Material: Color RGB 110-110-110, Color RGB 121-089-089, Color RGB 040-040-040, Color RGB 245-245-245, Color RGB 200-200-200, Color RGB 255-009-015, Color RGB 180-180-180, Color RGB 187-080-046, Color RGB 072-102-244
Type - Pset_DistributionFlowElementCommon - Reference: FDTC40VH
Type - Pset_ManufacturerTypeInformation - Manufacturer: Mitsubishi Heavy Industries
Type - Pset_QuantityTakeOff - Reference: FDTC40VH
Material: Color RGB 255-009-015, Color RGB 040-040-040, Color RGB 245-245-245, Color RGB 187-080-046, Color RGB 121-089-089, Color RGB 110-110-110, Color RGB 072-102-244
Pset_DistributionFlowElementCommon - sets with these values: 2
Name (HC_Air Conditioner_Indoor Unit_MEPcontent_Mitsubishi Heavy Industries_PAC_FDTC40-60VH_INT-EN:FDTC40VH:...) | In
792335 | 1026
797577 | 1012
802101 | 1010
806247 | 1011
806359 | 1011
806367 | 1011

# IfcEnergyConversionDevice: HC_Air Conditioner_Indoor Unit_MEPcontent_Mitsubishi Heavy Industries_PAC_FDTC40-60VH_INT-EN:FDTC40VH (4)
Type - PredefinedType: AIRCONDITIONINGUNIT; Material: Color RGB 187-080-046, Color RGB 180-180-180, Color RGB 072-102-244, Color RGB 121-089-089, Color RGB 245-245-245, Color RGB 110-110-110, Color RGB 200-200-200, Color RGB 040-040-040, Color RGB 255-009-015
Type - Pset_DistributionFlowElementCommon - Reference: FDTC40VH
Type - Pset_ManufacturerTypeInformation - Manufacturer: Mitsubishi Heavy Industries
Type - Pset_QuantityTakeOff - Reference: FDTC40VH
Material: Color RGB 255-009-015, Color RGB 040-040-040, Color RGB 245-245-245, Color RGB 187-080-046, Color RGB 121-089-089, Color RGB 110-110-110, Color RGB 072-102-244
Pset_DistributionFlowElementCommon - sets with these values: 2
Name (HC_Air Conditioner_Indoor Unit_MEPcontent_Mitsubishi Heavy Industries_PAC_FDTC40-60VH_INT-EN:FDTC40VH:...) | In
781229 | 1023
786421 | 1027
792151 | 1025
796492 | 1024

# IfcFlowFitting: M_Hranaté koleno, poloměr:1 W (13)
Type - Pset_DistributionFlowElementCommon - Reference: 1 W
Type - Pset_QuantityTakeOff - Reference: 1 W
Pset_DistributionFlowElementCommon - sets with these values: 2
Name (M_Hranaté koleno, poloměr:1 W:...) | In | Group
850267 | 12NP_STRECHA_VZT | Mechanické Odvod_ZAR_1 1
857452 | 12NP_STRECHA_VZT | Mechanické Odvod_ZAR_1 1
887350 | 1011 | Mechanické Odvod_ZAR_1 1
887376 | 1011 | Mechanické Odvod_ZAR_1 1
889075 | 12NP_STRECHA_VZT | Mechanické Prívod_ZAR_1 1
889135 | 12NP_STRECHA_VZT | Mechanické Prívod_ZAR_1 1
889508 | 10NP_VZT | Mechanické Prívod_ZAR_1 1
889510 | 10NP_VZT | Mechanické Prívod_ZAR_1 1
889832 | 1011 | Mechanické Prívod_ZAR_1 1
909811 | 10NP_VZT | Mechanické Odvod_ZAR_1 1
912096 | 1011 | Mechanické Prívod_ZAR_1 1
1131828 | 12NP_STRECHA_VZT | Mechanické Odvod_ZAR_1 1
1148865 | 12NP_STRECHA_VZT | Mechanické Odvod_ZAR_1 1

# IfcFlowFitting: M_Hranaté spojení:Standardní (2)
In: 12NP_STRECHA_VZT
Type - Pset_DistributionFlowElementCommon - Reference: Standardní
Type - Pset_QuantityTakeOff - Reference: Standardní
Pset_DistributionFlowElementCommon - sets with these values: 2
Name (M_Hranaté spojení:Standardní:...) | Group
863690 | Mechanické Prívod_ZAR_1 1
909774 | Mechanické Odvod_ZAR_1 1

# IfcFlowFitting: M_Hranatý přechod, úhel:15 stupňů (4)
In: 1011
Type - Pset_DistributionFlowElementCommon - Reference: 15 stupňů
Type - Pset_QuantityTakeOff - Reference: 15 stupňů
Pset_DistributionFlowElementCommon - sets with these values: 2
Name (M_Hranatý přechod, úhel:15 stupňů:...) | Group
909024 | Mechanické Prívod_ZAR_1 1
909110 | Mechanické Prívod_ZAR_1 1
909175 | Mechanické Prívod_ZAR_1 1
909304 | Mechanické Odvod_ZAR_1 1

# IfcFlowFitting: M_Hranatý přechod, úhel:45 stupňů (3)
Type - Pset_DistributionFlowElementCommon - Reference: 45 stupňů
Type - Pset_QuantityTakeOff - Reference: 45 stupňů
Pset_DistributionFlowElementCommon - sets with these values: 2
Name (M_Hranatý přechod, úhel:45 stupňů:...) | In | Group
912090 | 1011 | Mechanické Prívod_ZAR_1 1
1137095 | 12NP_STRECHA_VZT | Mechanické Prívod_ZAR_1 1
1148868 | 12NP_STRECHA_VZT | Mechanické Odvod_ZAR_1 1

# IfcFlowFitting: M_Kulaté koleno:1.5 D (53)
Type - Pset_DistributionFlowElementCommon - Reference: 1.5 D
Type - Pset_QuantityTakeOff - Reference: 1.5 D
Pset_DistributionFlowElementCommon - sets with these values: 2
Name (M_Kulaté koleno:1.5 D:...) | In | Group
729926 | 1014 | Mechanické Odvod_ZAR_2 2
729994 | 1016 | Mechanické Odvod_ZAR_2 2
738323 | 10NP_VZT | Mechanické Prívod_ZAR_2 1
741612 | 1023 | Mechanické Prívod_ZAR_2 1
741976 | 1009 | Mechanické Prívod_ZAR_2 1
747324 | 10NP_VZT | Mechanické Odvod_ZAR_2 2
753129 | 1009 | Mechanické Odvod_ZAR_2 2
783840 | 1024 | Mechanické Prívod_ZAR_2 1
784004 | 1027 | Mechanické Prívod_ZAR_2 1
784685 | 10NP_VZT | Mechanické Odvod_ZAR_2 2
784943 | 1027 | Mechanické Prívod_ZAR_2 1
784956 | 1027 | Mechanické Prívod_ZAR_2 1
785622 | 1009 | Mechanické Odvod_ZAR_2 2
785876 | 1009 | Mechanické Odvod_ZAR_2 2
790756 | 10NP_VZT | Mechanické Odvod_ZAR_2 2
790796 | 10NP_VZT | Mechanické Prívod_ZAR_2 1
803358 | 1009 | Mechanické Odvod_ZAR_2 2
803372 | 10NP_VZT | Mechanické Odvod_ZAR_2 2
804358 | 1009 | Mechanické Odvod_ZAR_2 2
804462 | 1009 | Mechanické Odvod_ZAR_2 2
804602 | 1009 | Mechanické Odvod_ZAR_2 2
811367 | 1011 | Mechanické Odvod_ZAR_1 1
811431 | 1011 | Mechanické Odvod_ZAR_1 1
815652 | 1011 | Mechanické Odvod_ZAR_1 1
816187 | 1011 | Mechanické Odvod_ZAR_1 1
818860 | 1011 | Mechanické Odvod_ZAR_1 1
822556 | 1011 | Mechanické Odvod_ZAR_1 1
836827 | 10NP_VZT | Mechanické Prívod_ZAR_2 1
851614 | 10NP_VZT | Mechanické Odvod_ZAR_2 2
851639 | 10NP_VZT | Mechanické Prívod_ZAR_2 1
887429 | 1011 | Mechanické Odvod_ZAR_1 1
887483 | 1011 | Mechanické Odvod_ZAR_1 1
889946 | 1011 | Mechanické Prívod_ZAR_1 1
921615 | 1009 | Mechanické Odvod_ZAR_2 2
937677 | 1009 | Mechanické Odvod_ZAR_2 2
937682 | 1009 | Mechanické Odvod_ZAR_2 2
939015 | 1009 | Mechanické Odvod_ZAR_2 2
951813 | 12NP_STRECHA_VZT | Mechanické Prívod_ZAR_2 1
951874 | 12NP_STRECHA_VZT | Mechanické Prívod_ZAR_2 1
952049 | 12NP_STRECHA_VZT | Mechanické Prívod_ZAR_2 1
952162 | 12NP_STRECHA_VZT | Mechanické Odvod_ZAR_2 2
952233 | 12NP_STRECHA_VZT | Mechanické Odvod_ZAR_2 2
1047567 | 10NP_VZT | Mechanické Odvod_ZAR_3 1
1048748 | 1019 | Mechanické Odvod_ZAR_3 1
1048956 | 1021 | Mechanické Odvod_ZAR_3 1
1064000 | 10NP_VZT | Mechanické Odvod_ZAR_3 1
1096887 | 1011 | Mechanické Odvod_ZAR_3 1
1149851 | 12NP_STRECHA_VZT | Mechanické Odvod_ZAR_2 2
1150011 | 12NP_STRECHA_VZT | Mechanické Odvod_ZAR_2 2
1150096 | 10NP_VZT | Mechanické Odvod_ZAR_2 2
1150111 | 12NP_STRECHA_VZT | Mechanické Odvod_ZAR_2 2
1151236 | 12NP_STRECHA_VZT | Mechanické Přiváděný vzduch 3
1151325 | 12NP_STRECHA_VZT | Mechanické Odvod_ZAR_2 1

# IfcFlowFitting: M_Kulaté křížení:Standardní, M_Kulaté křížení:Standardní:750249
In: 1009
Type - Pset_DistributionFlowElementCommon - Reference: Standardní
Type - Pset_QuantityTakeOff - Reference: Standardní
Pset_DistributionFlowElementCommon - sets with these values: 2
Group: Mechanické Prívod_ZAR_2 1

# IfcFlowFitting: M_Kulaté odbočení:Standardní (41)
Type - Pset_DistributionFlowElementCommon - Reference: Standardní
Type - Pset_QuantityTakeOff - Reference: Standardní
Pset_DistributionFlowElementCommon - sets with these values: 2
Name (M_Kulaté odbočení:Standardní:...) | In | Group
783971 | 1009 | Mechanické Prívod_ZAR_2 1
785116 | 1027 | Mechanické Odvod_ZAR_2 2
802518 | 1009 | Mechanické Prívod_ZAR_2 1
803188 | 1009 | Mechanické Odvod_ZAR_2 2
803605 | 1024 | Mechanické Odvod_ZAR_2 2
803873 | 1009 | Mechanické Prívod_ZAR_2 1
804364 | 1009 | Mechanické Odvod_ZAR_2 2
804468 | 1009 | Mechanické Odvod_ZAR_2 2
804608 | 1009 | Mechanické Odvod_ZAR_2 2
812608 | 1011 | Mechanické Prívod_ZAR_1 1
812715 | 1011 | Mechanické Prívod_ZAR_1 1
813333 | 1011 | Mechanické Prívod_ZAR_1 1
813366 | 1011 | Mechanické Prívod_ZAR_1 1
813586 | 1011 | Mechanické Prívod_ZAR_1 1
814845 | 1011 | Mechanické Prívod_ZAR_1 1
814847 | 1011 | Mechanické Prívod_ZAR_1 1
815656 | 1011 | Mechanické Odvod_ZAR_1 1
816191 | 1011 | Mechanické Odvod_ZAR_1 1
887436 | 1011 | Mechanické Odvod_ZAR_1 1
887488 | 1011 | Mechanické Odvod_ZAR_1 1
889951 | 1011 | Mechanické Prívod_ZAR_1 1
909256 | 1011 | Mechanické Prívod_ZAR_1 1
921317 | 1014 | Mechanické Odvod_ZAR_2 2
921397 | 1014 | Mechanické Odvod_ZAR_2 2
921551 | 1009 | Mechanické Odvod_ZAR_2 2
922494 | 1009 | Mechanické Odvod_ZAR_2 2
922587 | 1016 | Mechanické Odvod_ZAR_2 2
922625 | 1016 | Mechanické Odvod_ZAR_2 2
922684 | 1009 | Mechanické Odvod_ZAR_2 2
922742 | 1009 | Mechanické Odvod_ZAR_2 2
938784 | 1023 | Mechanické Odvod_ZAR_2 3
939223 | 1009 | Mechanické Odvod_ZAR_2 2
1048290 | 1021 | Mechanické Odvod_ZAR_3 1
1048433 | 1011 | Mechanické Odvod_ZAR_3 1
1048516 | 1019 | Mechanické Odvod_ZAR_3 1
1048520 | 1019 | Mechanické Odvod_ZAR_3 1
1048718 | 1011 | Mechanické Odvod_ZAR_3 1
1048783 | 1011 | Mechanické Odvod_ZAR_3 1
1097475 | 1021 | Mechanické Odvod_ZAR_3 1
1097512 | 1021 | Mechanické Odvod_ZAR_3 1
1103808 | 1011 | Mechanické Odvod_ZAR_1 1

# IfcFlowFitting: M_Kulaté spojení:Standardní (3)
In: 10NP_VZT
Type - Pset_DistributionFlowElementCommon - Reference: Standardní
Type - Pset_QuantityTakeOff - Reference: Standardní
Pset_DistributionFlowElementCommon - sets with these values: 2
Name (M_Kulaté spojení:Standardní:...) | Group
851259 | Mechanické Prívod_ZAR_2 1
851400 | Mechanické Odvod_ZAR_2 2
1151963 | Mechanické Odvod_ZAR_3 1

# IfcFlowFitting: M_Kulatý přechod, úhel:15 stupňů (22)
Type - Pset_DistributionFlowElementCommon - Reference: 15 stupňů
Type - Pset_QuantityTakeOff - Reference: 15 stupňů
Pset_DistributionFlowElementCommon - sets with these values: 2
Name (M_Kulatý přechod, úhel:15 stupňů:...) | In | Group
741575 | 1023 | Mechanické Prívod_ZAR_2 1
741978 | 1009 | Mechanické Prívod_ZAR_2 1
750990 | 1009 | Mechanické Prívod_ZAR_2 1
751222 | 1009 | Mechanické Odvod_ZAR_2 2
751544 | 1009 | Mechanické Odvod_ZAR_2 2
751564 | 1009 | Mechanické Odvod_ZAR_2 2
751567 | 1009 | Mechanické Odvod_ZAR_2 2
783834 | 1024 | Mechanické Prívod_ZAR_2 1
783930 | 1009 | Mechanické Prívod_ZAR_2 1
783998 | 1027 | Mechanické Prívod_ZAR_2 1
814921 | 1012 | Mechanické Prívod_ZAR_1 1
817366 | 1012 | Mechanické Odvod_ZAR_1 1
921546 | 1014 | Mechanické Odvod_ZAR_2 2
922679 | 1016 | Mechanické Odvod_ZAR_2 2
1048739 | 1019 | Mechanické Odvod_ZAR_3 1
1082408 | 1011 | Mechanické Odvod_ZAR_3 1
1097412 | 1021 | Mechanické Odvod_ZAR_3 1
1103803 | 1011 | Mechanické Odvod_ZAR_1 1
1149899 | 12NP_STRECHA_VZT | Mechanické Prívod_ZAR_2 1
1149901 | 12NP_STRECHA_VZT | Mechanické Prívod_ZAR_2 1
1149982 | 12NP_STRECHA_VZT | Mechanické Odvod_ZAR_2 2
1150024 | 12NP_STRECHA_VZT | Mechanické Odvod_ZAR_2 2

# IfcFlowFitting: M_Kulatý přechod, úhel:30 stupňů (4)
Type - Pset_DistributionFlowElementCommon - Reference: 30 stupňů
Type - Pset_QuantityTakeOff - Reference: 30 stupňů
Pset_DistributionFlowElementCommon - sets with these values: 2
Name (M_Kulatý přechod, úhel:30 stupňů:...) | In | Group
784683 | 1027 | Mechanické Odvod_ZAR_2 2
803370 | 1024 | Mechanické Odvod_ZAR_2 2
938867 | 1023 | Mechanické Odvod_ZAR_2 3
1097409 | 1021 | Mechanické Odvod_ZAR_3 1

# IfcFlowFitting: M_Kulatý přechod, úhel:45 stupňů (2)
In: 1009
Type - Pset_DistributionFlowElementCommon - Reference: 45 stupňů
Type - Pset_QuantityTakeOff - Reference: 45 stupňů
Pset_DistributionFlowElementCommon - sets with these values: 2
Group: Mechanické Odvod_ZAR_2 2
Name (M_Kulatý přechod, úhel:45 stupňů:...)
921618
937643

# IfcFlowFitting: M_Kulatý přechod, úhel:60 stupňů (2)
In: 12NP_STRECHA_VZT
Type - Pset_DistributionFlowElementCommon - Reference: 60 stupňů
Type - Pset_QuantityTakeOff - Reference: 60 stupňů
Pset_DistributionFlowElementCommon - sets with these values: 2
Name (M_Kulatý přechod, úhel:60 stupňů:...) | Group
1151256 | Mechanické Přiváděný vzduch 3
1151341 | Mechanické Odvod_ZAR_2 1

# IfcFlowFitting: M_Kulatý spoj T:Standardní (6)
Type - Pset_DistributionFlowElementCommon - Reference: Standardní
Type - Pset_QuantityTakeOff - Reference: Standardní
Pset_DistributionFlowElementCommon - sets with these values: 2
Name (M_Kulatý spoj T:Standardní:...) | In | Group
741724 | 1023 | Mechanické Prívod_ZAR_2 1
741750 | 1009 | Mechanické Prívod_ZAR_2 1
783844 | 1024 | Mechanické Prívod_ZAR_2 1
784006 | 1027 | Mechanické Prívod_ZAR_2 1
814925 | 1012 | Mechanické Prívod_ZAR_1 1
817453 | 1012 | Mechanické Odvod_ZAR_1 1

# IfcFlowFitting: M_Přechod, hranaté na kulaté, úhel:15 stupňů, M_Přechod, hranaté na kulaté, úhel:15 stupňů:1103801
In: 1011
Type - Pset_DistributionFlowElementCommon - Reference: 15 stupňů
Type - Pset_QuantityTakeOff - Reference: 15 stupňů
Pset_DistributionFlowElementCommon - sets with these values: 2
Group: Mechanické Odvod_ZAR_1 1

# IfcFlowFitting: M_Přechod, hranaté na kulaté, úhel:45 stupňů, M_Přechod, hranaté na kulaté, úhel:45 stupňů:1109964
In: 1011
Type - Pset_DistributionFlowElementCommon - Reference: 45 stupňů
Type - Pset_QuantityTakeOff - Reference: 45 stupňů
Pset_DistributionFlowElementCommon - sets with these values: 2
Group: Mechanické Prívod_ZAR_1 1

# IfcFlowFitting: M_Přechod, obecný:Standardní, M_Přechod, obecný:Standardní:766715
In: 1023
Type - Pset_DistributionFlowElementCommon - Reference: Standardní
Type - Pset_QuantityTakeOff - Reference: Standardní
Pset_DistributionFlowElementCommon - sets with these values: 2
Group: Teplovodní přívod 1

# IfcFlowSegment: Hranaté potrubí:Kolena s úkosem / spoje T (27)
In: 10NP_VZT
Type - Pset_DistributionFlowElementCommon - Reference: Kolena s úkosem / spoje T
Type - Pset_QuantityTakeOff - Reference: Kolena s úkosem / spoje T
Pset_DistributionFlowElementCommon - sets with these values: 2
Pset_DuctSegmentTypeCommon - Shape: Rectangle
Pset_FlowSegmentDuctSegment - sets with these values: 2
Name (Hranaté potrubí:Kolena s úkosem / spoje T:...) | Pset_DuctSegmentTypeCommon, Length (mm) = Pset_FlowSegmentDuctSegment, Length (mm) | Group
799087 | 84 | Mechanické Přiváděný vzduch 2
799423 | 100 | Mechanické Přiváděný vzduch 6
799653 | 100 | Mechanické Přiváděný vzduch 9
799666 | 100 | Mechanické Přiváděný vzduch 10
801223 | 100 | Mechanické Přiváděný vzduch 25
801262 | 84 | Mechanické Přiváděný vzduch 26
801310 | 84 | Mechanické Přiváděný vzduch 27
801332 | 84 | Mechanické Přiváděný vzduch 28
801353 | 84 | Mechanické Přiváděný vzduch 29
801403 | 84 | Mechanické Přiváděný vzduch 30
801416 | 84 | Mechanické Přiváděný vzduch 31
801429 | 84 | Mechanické Přiváděný vzduch 32
801442 | 84 | Mechanické Přiváděný vzduch 33
801455 | 84 | Mechanické Přiváděný vzduch 34
801468 | 84 | Mechanické Přiváděný vzduch 35
801500 | 84 | Mechanické Přiváděný vzduch 37
801515 | 84 | Mechanické Přiváděný vzduch 38
801627 | 84 | Mechanické Přiváděný vzduch 36
807910 | 400 | Mechanické Prívod_ZAR_1 1
809895 | 400 | Mechanické Odvod_ZAR_1 1
810663 | 315 | Mechanické Prívod_ZAR_1 1
811768 | 400 | Mechanické Odvod_ZAR_1 1
815741 | 400 | Mechanické Odvod_ZAR_1 1
884902 | 400 | Mechanické Odvod_ZAR_1 1
886914 | 400 | Mechanické Odvod_ZAR_1 1
888391 | 400 | Mechanické Odvod_ZAR_1 1
889607 | 400 | Mechanické Prívod_ZAR_1 1

# IfcFlowSegment: Hranaté potrubí:Kolena s úkosem / vývody (23)
Type - Pset_DistributionFlowElementCommon - Reference: Kolena s úkosem / vývody
Type - Pset_QuantityTakeOff - Reference: Kolena s úkosem / vývody
Pset_DistributionFlowElementCommon - sets with these values: 2
Pset_DuctSegmentTypeCommon - Shape: Rectangle
Pset_FlowSegmentDuctSegment - sets with these values: 2
Name (Hranaté potrubí:Kolena s úkosem / vývody:...) | In | Pset_DuctSegmentTypeCommon, Length (mm) = Pset_FlowSegmentDuctSegment, Length (mm) | Group
812746 | 10NP_VZT | 315 | Mechanické Prívod_ZAR_1 1
813434 | 10NP_VZT | 315 | Mechanické Prívod_ZAR_1 1
814087 | 10NP_VZT | 315 | Mechanické Prívod_ZAR_1 1
824520 | 10NP_VZT | 315 | Mechanické Prívod_ZAR_1 1
850248 | 12NP_STRECHA_VZT | 1497.04 | Mechanické Odvod_ZAR_1 1
850262 | 12NP_STRECHA_VZT | 400 | Mechanické Odvod_ZAR_1 1
850351 | 12NP_STRECHA_VZT | 552.04 | Mechanické Prívod_ZAR_1 1
863689 | 12NP_STRECHA_VZT | 3937.1 | Mechanické Prívod_ZAR_1 1
870526 | 12NP_STRECHA_VZT | 400 | Mechanické Prívod_ZAR_1 1
889126 | 10NP_VZT | 400 | Mechanické Prívod_ZAR_1 1
889278 | 10NP_VZT | 400 | Mechanické Prívod_ZAR_1 1
889750 | 10NP_VZT | 400 | Mechanické Prívod_ZAR_1 1
909799 | 10NP_VZT | 3812.4 | Mechanické Odvod_ZAR_1 1
909940 | 12NP_STRECHA_VZT | 760 | Mechanické Odvod_ZAR_1 1
912082 | 10NP_VZT | 400 | Mechanické Prívod_ZAR_1 1
951342 | 12NP_STRECHA_VZT | 760 | Mechanické Prívod_ZAR_1 1
951422 | 12NP_STRECHA_VZT | 760 | Mechanické Odvod_ZAR_1 1
951432 | 12NP_STRECHA_VZT | 760 | Mechanické Odvod_ZAR_1 1
1137017 | 12NP_STRECHA_VZT | 760 | Mechanické Prívod_ZAR_1 1
1143069 | 12NP_STRECHA_VZT | 760 | Mechanické Prívod_ZAR_1 1
1148442 | 12NP_STRECHA_VZT | 760 | Mechanické Odvod_ZAR_1 1
1148791 | 12NP_STRECHA_VZT | 400 | Mechanické Odvod_ZAR_1 1
1148799 | 12NP_STRECHA_VZT | 400 | Mechanické Odvod_ZAR_1 1

# IfcFlowSegment: Kulaté ohebné potrubí:Ohyb – zaoblený (54)
In: 10NP_VZT
Type - PredefinedType: FLEXIBLESEGMENT
Type - Pset_DistributionFlowElementCommon - Reference: Ohyb – zaoblený
Type - Pset_QuantityTakeOff - Reference: Ohyb – zaoblený
Pset_DistributionFlowElementCommon - sets with these values: 2
Name (Kulaté ohebné potrubí:Ohyb – zaoblený:...) | Group
741778 | Mechanické Prívod_ZAR_2 1
749242 | Mechanické Prívod_ZAR_2 1
755338 | Mechanické Prívod_ZAR_2 1
755358 | Mechanické Prívod_ZAR_2 1
783856 | Mechanické Prívod_ZAR_2 1
783859 | Mechanické Prívod_ZAR_2 1
784014 | Mechanické Prívod_ZAR_2 1
784017 | Mechanické Prívod_ZAR_2 1
784649 | Mechanické Odváděný vzduch 2; Mechanické Odvod_ZAR_2 2
784651 | Mechanické Odváděný vzduch 2; Mechanické Odvod_ZAR_2 2
791726 | Mechanické Prívod_ZAR_2 1
791753 | Mechanické Prívod_ZAR_2 1
792002 | Mechanické Odváděný vzduch 2; Mechanické Odvod_ZAR_2 2
792105 | Mechanické Odváděný vzduch 2; Mechanické Odvod_ZAR_2 2
792606 | Mechanické Odvod_ZAR_1 1
792608 | Mechanické Odvod_ZAR_1 1
803366 | Mechanické Odváděný vzduch 2; Mechanické Odvod_ZAR_2 2
803368 | Mechanické Odváděný vzduch 2; Mechanické Odvod_ZAR_2 2
812143 | Mechanické Odvod_ZAR_1 1
815608 | Mechanické Odvod_ZAR_1 1
816134 | Mechanické Odvod_ZAR_1 1
817111 | Mechanické Odvod_ZAR_1 1
838640 | Mechanické Prívod_ZAR_1 1
838643 | Mechanické Prívod_ZAR_1 1
838646 | Mechanické Prívod_ZAR_1 1
838649 | Mechanické Prívod_ZAR_1 1
838652 | Mechanické Prívod_ZAR_1 1
838655 | Mechanické Prívod_ZAR_1 1
838658 | Mechanické Prívod_ZAR_1 1
838984 | Mechanické Prívod_ZAR_1 1
839473 | Mechanické Prívod_ZAR_1 1
840506 | Mechanické Odvod_ZAR_1 1
890663 | Mechanické Prívod_ZAR_1 1
921695 | Mechanické Odváděný vzduch 2; Mechanické Odvod_ZAR_2 2
922818 | Mechanické Odvod_ZAR_1 2; Mechanické Odváděný vzduch 2; Mechanické Odvod_ZAR_2 2
922822 | Mechanické Odváděný vzduch 2; Mechanické Odvod_ZAR_2 2; Mechanické Odvod_ZAR_1 3
922826 | Mechanické Odváděný vzduch 2; Mechanické Odvod_ZAR_2 2; Mechanické Odvod_ZAR_1 4
922830 | Mechanické Odváděný vzduch 2; Mechanické Odvod_ZAR_2 2; Mechanické Odvod_ZAR_1 5
922834 | Mechanické Odváděný vzduch 2; Mechanické Odvod_ZAR_1 6; Mechanické Odvod_ZAR_2 2
922838 | Mechanické Odváděný vzduch 2; Mechanické Odvod_ZAR_2 2; Mechanické Odvod_ZAR_1 7
922842 | Mechanické Odváděný vzduch 2; Mechanické Odvod_ZAR_2 2; Mechanické Odvod_ZAR_1 8
922846 | Mechanické Odváděný vzduch 2; Mechanické Odvod_ZAR_2 2; Mechanické Odvod_ZAR_1 9
938813 | Mechanické Odváděný vzduch 2; Mechanické Odvod_ZAR_2 3
938864 | Mechanické Odváděný vzduch 2; Mechanické Odvod_ZAR_2 3
1048323 | Mechanické Odvod_ZAR_3 1
1048327 | Mechanické Odvod_ZAR_3 1
1048421 | Mechanické Odvod_ZAR_3 1
1048452 | Mechanické Odvod_ZAR_3 1
1048761 | Mechanické Odvod_ZAR_3 1
1048765 | Mechanické Odvod_ZAR_3 1
1048769 | Mechanické Odvod_ZAR_3 1
1048794 | Mechanické Odvod_ZAR_3 1
1097301 | Mechanické Odvod_ZAR_3 1
1110515 | Mechanické Prívod_ZAR_1 1

# IfcFlowSegment: Kulaté potrubí:Spoje T (11)
In: 10NP_VZT
Type - Pset_DistributionFlowElementCommon - Reference: Spoje T
Type - Pset_QuantityTakeOff - Reference: Spoje T
Pset_DistributionFlowElementCommon - sets with these values: 2
Pset_DuctSegmentTypeCommon - Shape: Round
Pset_FlowSegmentDuctSegment - sets with these values: 2
Name (Kulaté potrubí:Spoje T:...) | Pset_DuctSegmentTypeCommon, Length (mm) = Pset_FlowSegmentDuctSegment, Length (mm) | Group
784929 | 400.25 | Mechanické Prívod_ZAR_2 1
784937 | 165 | Mechanické Prívod_ZAR_2 1
784946 | 3004.47 | Mechanické Prívod_ZAR_2 1
788012 | 1401.9 | Mechanické Prívod_ZAR_2 1
790681 | 2452.15 | Mechanické Odvod_ZAR_2 2
790784 | 216.527 | Mechanické Prívod_ZAR_2 1
790830 | 54.4725 | Mechanické Odvod_ZAR_2 2
790840 | 3203.91 | Mechanické Odvod_ZAR_2 2
791473 | 744.819 | Mechanické Odvod_ZAR_2 2
811344 | 112.304 | Mechanické Odvod_ZAR_1 1
851397 | 900.105 | Mechanické Odvod_ZAR_2 2

# IfcFlowSegment: Kulaté potrubí:Vývody (170)
Type - Pset_DistributionFlowElementCommon - Reference: Vývody
Type - Pset_QuantityTakeOff - Reference: Vývody
Pset_DistributionFlowElementCommon - sets with these values: 2
Pset_DuctSegmentTypeCommon - Shape: Round
Pset_FlowSegmentDuctSegment - sets with these values: 2
Name (Kulaté potrubí:Vývody:...) | In | Pset_DuctSegmentTypeCommon, Length (mm) = Pset_FlowSegmentDuctSegment, Length (mm) | Group
729916 | 10NP_VZT | 515.9 | Mechanické Odvod_ZAR_2 2
729920 | 10NP_VZT | 107.751 | Mechanické Odvod_ZAR_2 2
729924 | 10NP_VZT | 289.241 | Mechanické Odvod_ZAR_2 2
729928 | 10NP_VZT | 515.9 | Mechanické Odvod_ZAR_2 2
729986 | 10NP_VZT | 515.9 | Mechanické Odvod_ZAR_2 2
729990 | 10NP_VZT | 107.751 | Mechanické Odvod_ZAR_2 2
729992 | 10NP_VZT | 289.241 | Mechanické Odvod_ZAR_2 2
729996 | 10NP_VZT | 515.9 | Mechanické Odvod_ZAR_2 2
730036 | 10NP_VZT | 252.252 | Mechanické Prívod_ZAR_2 1
738253 | 10NP_VZT | 6869.69 | Mechanické Prívod_ZAR_2 1
738311 | 10NP_VZT | 3019.74 | Mechanické Prívod_ZAR_2 1
738326 | 10NP_VZT | 54.4725 | Mechanické Prívod_ZAR_2 1
738684 | 10NP_VZT | 3219.08 | Mechanické Prívod_ZAR_2 1
738952 | 10NP_VZT | 5057.92 | Mechanické Prívod_ZAR_2 1
741543 | 10NP_VZT | 2120 | Mechanické Prívod_ZAR_2 1
741579 | 10NP_VZT | 699.398 | Mechanické Prívod_ZAR_2 1
741604 | 10NP_VZT | 177.333 | Mechanické Prívod_ZAR_2 1
741616 | 10NP_VZT | 256.095 | Mechanické Prívod_ZAR_2 1
741725 | 10NP_VZT | 76.2396 | Mechanické Prívod_ZAR_2 1
741751 | 10NP_VZT | 5947.75 | Mechanické Prívod_ZAR_2 1
745113 | 10NP_VZT | 255.733 | Mechanické Prívod_ZAR_2 1
745141 | 10NP_VZT | 5037.14 | Mechanické Prívod_ZAR_2 1
746306 | 10NP_VZT | 4100.5 | Mechanické Prívod_ZAR_2 1
747246 | 10NP_VZT | 9589.89 | Mechanické Odvod_ZAR_2 2
747938 | 10NP_VZT | 520.589 | Mechanické Odvod_ZAR_2 2
748253 | 10NP_VZT | 5400 | Mechanické Odvod_ZAR_2 2
748513 | 10NP_VZT | 4740 | Mechanické Odvod_ZAR_2 2
748522 | 10NP_VZT | 478.846 | Mechanické Odvod_ZAR_2 2
749971 | 10NP_VZT | 283.115 | Mechanické Prívod_ZAR_2 1
750253 | 10NP_VZT | 5338.28 | Mechanické Prívod_ZAR_2 1
750440 | 10NP_VZT | 92.1527 | Mechanické Odvod_ZAR_2 2
750532 | 10NP_VZT | 458.089 | Mechanické Odvod_ZAR_2 2
751424 | 10NP_VZT | 639.822 | Mechanické Odvod_ZAR_2 2
751432 | 10NP_VZT | 120.265 | Mechanické Odvod_ZAR_2 2
751548 | 10NP_VZT | 1091.07 | Mechanické Odvod_ZAR_2 2
752778 | 10NP_VZT | 356.802 | Mechanické Odvod_ZAR_2 2
752947 | 10NP_VZT | 182.175 | Mechanické Odvod_ZAR_2 2
753117 | 10NP_VZT | 463.845 | Mechanické Odvod_ZAR_2 2
753200 | 10NP_VZT | 437.574 | Mechanické Odvod_ZAR_2 2
753204 | 10NP_VZT | 182.175 | Mechanické Odvod_ZAR_2 2
753210 | 10NP_VZT | 226.883 | Mechanické Odvod_ZAR_2 2
783832 | 10NP_VZT | 2120 | Mechanické Prívod_ZAR_2 1
783836 | 10NP_VZT | 579.398 | Mechanické Prívod_ZAR_2 1
783838 | 10NP_VZT | 273.233 | Mechanické Prívod_ZAR_2 1
783845 | 10NP_VZT | 196.24 | Mechanické Prívod_ZAR_2 1
783853 | 10NP_VZT | 4100.5 | Mechanické Prívod_ZAR_2 1
783996 | 10NP_VZT | 2120 | Mechanické Prívod_ZAR_2 1
784000 | 10NP_VZT | 619.398 | Mechanické Prívod_ZAR_2 1
784002 | 10NP_VZT | 256.515 | Mechanické Prívod_ZAR_2 1
784007 | 10NP_VZT | 436.24 | Mechanické Prívod_ZAR_2 1
784641 | 10NP_VZT | 329.019 | Mechanické Odvod_ZAR_2 2
784643 | 10NP_VZT | 2078.4 | Mechanické Odvod_ZAR_2 2
785619 | 10NP_VZT | 437.574 | Mechanické Odvod_ZAR_2 2
786652 | 10NP_VZT | 125.476 | Mechanické Odvod_ZAR_2 2
787234 | 10NP_VZT | 1337.23 | Mechanické Odvod_ZAR_2 2
787601 | 10NP_VZT | 873.607 | Mechanické Odvod_ZAR_2 2
789191 | 10NP_VZT | 50.7918 | Mechanické Odvod_ZAR_2 2
789599 | 10NP_VZT | 50.7918 | Mechanické Odvod_ZAR_2 2
789683 | 10NP_VZT | 55.7918 | Mechanické Odvod_ZAR_2 2
789859 | 10NP_VZT | 92.1805 | Mechanické Odvod_ZAR_2 2
790524 | 10NP_VZT | 38.2918 | Mechanické Odvod_ZAR_2 2
792602 | 10NP_VZT | 1583.14 | Mechanické Odvod_ZAR_1 1
793122 | 10NP_VZT | 3900 | Mechanické Prívod_ZAR_1 1
793127 | 10NP_VZT | 1852.71 | Mechanické Prívod_ZAR_1 1
803352 | 10NP_VZT | 356.802 | Mechanické Odvod_ZAR_2 2
803354 | 10NP_VZT | 202.239 | Mechanické Odvod_ZAR_2 2
803356 | 10NP_VZT | 463.845 | Mechanické Odvod_ZAR_2 2
803360 | 10NP_VZT | 369.019 | Mechanické Odvod_ZAR_2 2
803362 | 10NP_VZT | 2198.4 | Mechanické Odvod_ZAR_2 2
803377 | 10NP_VZT | 125.424 | Mechanické Odvod_ZAR_2 2
810311 | 10NP_VZT | 3169.58 | Mechanické Odvod_ZAR_1 1
811417 | 10NP_VZT | 1879 | Mechanické Odvod_ZAR_1 1
811425 | 10NP_VZT | 327.294 | Mechanické Odvod_ZAR_1 1
812113 | 10NP_VZT | 111.172 | Mechanické Odvod_ZAR_1 1
812124 | 10NP_VZT | 850 | Mechanické Odvod_ZAR_1 1
812600 | 10NP_VZT | 2320.76 | Mechanické Prívod_ZAR_1 1
812707 | 10NP_VZT | 100 | Mechanické Prívod_ZAR_1 1
812942 | 10NP_VZT | 2370.76 | Mechanické Prívod_ZAR_1 1
812944 | 10NP_VZT | 100 | Mechanické Prívod_ZAR_1 1
813496 | 10NP_VZT | 78.6231 | Mechanické Prívod_ZAR_1 1
813498 | 10NP_VZT | 110.154 | Mechanické Prívod_ZAR_1 1
814608 | 10NP_VZT | 2665.76 | Mechanické Prívod_ZAR_1 1
814610 | 10NP_VZT | 100 | Mechanické Prívod_ZAR_1 1
814919 | 10NP_VZT | 3480 | Mechanické Prívod_ZAR_1 1
814923 | 10NP_VZT | 3826.17 | Mechanické Prívod_ZAR_1 1
814926 | 10NP_VZT | 76.2396 | Mechanické Prívod_ZAR_1 1
815602 | 10NP_VZT | 111.172 | Mechanické Odvod_ZAR_1 1
815604 | 10NP_VZT | 878.893 | Mechanické Odvod_ZAR_1 1
816130 | 10NP_VZT | 187.3 | Mechanické Odvod_ZAR_1 1
816132 | 10NP_VZT | 129.777 | Mechanické Odvod_ZAR_1 1
816970 | 10NP_VZT | 879.8 | Mechanické Odvod_ZAR_1 1
817454 | 10NP_VZT | 123.933 | Mechanické Odvod_ZAR_1 1
817727 | 10NP_VZT | 6580 | Mechanické Odvod_ZAR_1 1
818166 | 10NP_VZT | 95.552 | Mechanické Odvod_ZAR_1 1
819309 | 10NP_VZT | 2355.47 | Mechanické Odvod_ZAR_1 1
819507 | 10NP_VZT | 1852.71 | Mechanické Odvod_ZAR_1 1
820729 | 10NP_VZT | 211.139 | Mechanické Odvod_ZAR_1 1
820864 | 10NP_VZT | 168.607 | Mechanické Odvod_ZAR_1 1
821104 | 10NP_VZT | 57.7231 | Mechanické Odvod_ZAR_1 1
821185 | 10NP_VZT | 91.0996 | Mechanické Odvod_ZAR_1 1
822389 | 10NP_VZT | 285.924 | Mechanické Odvod_ZAR_1 1
822547 | 10NP_VZT | 235.784 | Mechanické Odvod_ZAR_1 1
824658 | 10NP_VZT | 1066.84 | Mechanické Prívod_ZAR_1 1
851256 | 10NP_VZT | 860 | Mechanické Prívod_ZAR_2 1
922960 | 10NP_VZT | 1567.3 | Mechanické Odvod_ZAR_2 2
923089 | 10NP_VZT | 1495.7 | Mechanické Odvod_ZAR_2 2
928255 | 10NP_VZT | 602.608 | Mechanické Odvod_ZAR_2 2
928397 | 10NP_VZT | 912.608 | Mechanické Odvod_ZAR_2 2
929223 | 10NP_VZT | 810 | Mechanické Odvod_ZAR_2 2
936373 | 10NP_VZT | 472.402 | Mechanické Prívod_ZAR_1 1
937633 | 10NP_VZT | 73.431 | Mechanické Odvod_ZAR_2 2
938155 | 10NP_VZT | 53.431 | Mechanické Odvod_ZAR_2 2
938624 | 10NP_VZT | 741.167 | Mechanické Odvod_ZAR_2 3
938773 | 10NP_VZT | 2258.4 | Mechanické Odvod_ZAR_2 3
939001 | 10NP_VZT | 136.911 | Mechanické Odvod_ZAR_2 2
940694 | 10NP_VZT | 97.6388 | Mechanické Prívod_ZAR_1 1
940785 | 10NP_VZT | 119.2 | Mechanické Prívod_ZAR_1 1
940897 | 10NP_VZT | 127.639 | Mechanické Prívod_ZAR_1 1
940987 | 10NP_VZT | 119.2 | Mechanické Prívod_ZAR_1 1
941083 | 10NP_VZT | 2489.78 | Mechanické Prívod_ZAR_1 1
941127 | 10NP_VZT | 58.1769 | Mechanické Prívod_ZAR_1 1
941337 | 10NP_VZT | 58.1769 | Mechanické Prívod_ZAR_1 1
941403 | 10NP_VZT | 62.6388 | Mechanické Prívod_ZAR_1 1
951794 | 12NP_STRECHA_VZT | 253.181 | Mechanické Prívod_ZAR_2 1
951860 | 12NP_STRECHA_VZT | 611.751 | Mechanické Prívod_ZAR_2 1
951868 | 12NP_STRECHA_VZT | 51.0685 | Mechanické Prívod_ZAR_2 1
951895 | 12NP_STRECHA_VZT | 37.3255 | Mechanické Prívod_ZAR_2 1
952148 | 12NP_STRECHA_VZT | 40.579 | Mechanické Odvod_ZAR_2 2
952216 | 12NP_STRECHA_VZT | 50.815 | Mechanické Odvod_ZAR_2 2
952225 | 12NP_STRECHA_VZT | 615 | Mechanické Odvod_ZAR_2 2
952335 | 12NP_STRECHA_VZT | 40.495 | Mechanické Odvod_ZAR_2 1
952420 | 12NP_STRECHA_VZT | 40.493 | Mechanické Přiváděný vzduch 3
1047004 | 10NP_VZT | 80.8961 | Mechanické Odvod_ZAR_3 1
1047280 | 10NP_VZT | 3970.67 | Mechanické Odvod_ZAR_3 1
1047542 | 10NP_VZT | 163.717 | Mechanické Odvod_ZAR_3 1
1047558 | 10NP_VZT | 200 | Mechanické Odvod_ZAR_3 1
1048284 | 10NP_VZT | 278.4 | Mechanické Odvod_ZAR_3 1
1048303 | 10NP_VZT | 260.9 | Mechanické Odvod_ZAR_3 1
1048389 | 10NP_VZT | 149.066 | Mechanické Odvod_ZAR_3 1
1048397 | 10NP_VZT | 230 | Mechanické Odvod_ZAR_3 1
1048425 | 10NP_VZT | 27.5073 | Mechanické Odvod_ZAR_3 1
1048510 | 10NP_VZT | 270.594 | Mechanické Odvod_ZAR_3 1
1048514 | 10NP_VZT | 298.4 | Mechanické Odvod_ZAR_3 1
1048518 | 10NP_VZT | 298.4 | Mechanické Odvod_ZAR_3 1
1048731 | 10NP_VZT | 110 | Mechanické Odvod_ZAR_3 1
1048742 | 10NP_VZT | 170 | Mechanické Odvod_ZAR_3 1
1048773 | 10NP_VZT | 527.806 | Mechanické Odvod_ZAR_3 1
1053389 | 10NP_VZT | 330.594 | Mechanické Odvod_ZAR_3 1
1053533 | 10NP_VZT | 394.694 | Mechanické Odvod_ZAR_3 1
1053985 | 10NP_VZT | 1238.49 | Mechanické Odvod_ZAR_3 1
1054116 | 10NP_VZT | 925.994 | Mechanické Odvod_ZAR_3 1
1063936 | 10NP_VZT | 16499.9 | Mechanické Odvod_ZAR_3 1
1065265 | 10NP_VZT | 86.0809 | Mechanické Odvod_ZAR_3 1
1082118 | 10NP_VZT | 565 | Mechanické Odvod_ZAR_3 1
1082259 | 10NP_VZT | 548.198 | Mechanické Odvod_ZAR_3 1
1093719 | 10NP_VZT | 135 | Mechanické Odvod_ZAR_3 1
1093819 | 10NP_VZT | 131.802 | Mechanické Odvod_ZAR_3 1
1096863 | 10NP_VZT | 273.802 | Mechanické Odvod_ZAR_3 1
1097600 | 10NP_VZT | 287.182 | Mechanické Odvod_ZAR_3 1
1097834 | 10NP_VZT | 2068.32 | Mechanické Odvod_ZAR_3 1
1149896 | 12NP_STRECHA_VZT | 536.75 | Mechanické Prívod_ZAR_2 1
1149967 | 12NP_STRECHA_VZT | 303.028 | Mechanické Odvod_ZAR_2 2
1149994 | 12NP_STRECHA_VZT | 44.8174 | Mechanické Odvod_ZAR_2 2
1150088 | 12NP_STRECHA_VZT | 44.8168 | Mechanické Odvod_ZAR_2 2
1150102 | 12NP_STRECHA_VZT | 303.029 | Mechanické Odvod_ZAR_2 2
1151228 | 12NP_STRECHA_VZT | 17.5 | Mechanické Přiváděný vzduch 3
1151240 | 12NP_STRECHA_VZT | 21.0289 | Mechanické Přiváděný vzduch 3
1151319 | 12NP_STRECHA_VZT | 22.5 | Mechanické Odvod_ZAR_2 1
1151329 | 12NP_STRECHA_VZT | 21.0289 | Mechanické Odvod_ZAR_2 1
1151961 | 10NP_VZT | 4130.28 | Mechanické Odvod_ZAR_3 1

# IfcFlowTerminal: AD-11-CM-200-100:AD-11-CM-200-100 (28)
Type - Pset_DistributionFlowElementCommon - Reference: AD-11-CM-200-100
Type - Pset_ManufacturerTypeInformation - Manufacturer: Lindab
Type - Pset_QuantityTakeOff - Reference: AD-11-CM-200-100
Pset_DistributionFlowElementCommon - sets with these values: 2
Name (AD-11-CM-200-100:AD-11-CM-200-100:...) | In | Group
801129 | 1009 | Mechanické Přiváděný vzduch 11
801212 | 1013 | Mechanické Přiváděný vzduch 11
801260 | 1015 | Mechanické Přiváděný vzduch 12
801261 | 1009 | Mechanické Přiváděný vzduch 12
801308 | 1017 | Mechanické Přiváděný vzduch 13
801309 | 1009 | Mechanické Přiváděný vzduch 13
801330 | 1011 | Mechanické Přiváděný vzduch 14
801331 | 1018 | Mechanické Přiváděný vzduch 14
801351 | 1011 | Mechanické Přiváděný vzduch 15
801352 | 1020 | Mechanické Přiváděný vzduch 15
801401 | 1014 | Mechanické Přiváděný vzduch 16
801402 | 1014 | Mechanické Přiváděný vzduch 16
801414 | 1014 | Mechanické Přiváděný vzduch 17
801415 | 1014 | Mechanické Přiváděný vzduch 17
801427 | 1016 | Mechanické Přiváděný vzduch 18
801428 | 1016 | Mechanické Přiváděný vzduch 18
801440 | 1016 | Mechanické Přiváděný vzduch 19
801441 | 1016 | Mechanické Přiváděný vzduch 19
801453 | 1019 | Mechanické Přiváděný vzduch 20
801454 | 1019 | Mechanické Přiváděný vzduch 20
801466 | 1019 | Mechanické Přiváděný vzduch 21
801467 | 1019 | Mechanické Přiváděný vzduch 21
801483 | 1021 | Mechanické Přiváděný vzduch 22
801484 | 1021 | Mechanické Přiváděný vzduch 22
801498 | 1021 | Mechanické Přiváděný vzduch 23
801499 | 1021 | Mechanické Přiváděný vzduch 23
801513 | 1022 | Mechanické Přiváděný vzduch 24
801514 | 1011 | Mechanické Přiváděný vzduch 24

# IfcFlowTerminal: AD-11-CM-400-100:AD-11-CM-400-100 (8)
Type - Pset_DistributionFlowElementCommon - Reference: AD-11-CM-400-100
Type - Pset_ManufacturerTypeInformation - Manufacturer: Lindab
Type - Pset_QuantityTakeOff - Reference: AD-11-CM-400-100
Pset_DistributionFlowElementCommon - sets with these values: 2
Name (AD-11-CM-400-100:AD-11-CM-400-100:...) | In | Group
798988 | 1009 | Mechanické Přiváděný vzduch 1
799069 | 1014 | Mechanické Přiváděný vzduch 1
799421 | 1009 | Mechanické Přiváděný vzduch 5
799422 | 1016 | Mechanické Přiváděný vzduch 4
799651 | 1019 | Mechanické Přiváděný vzduch 7
799652 | 1011 | Mechanické Přiváděný vzduch 7
799664 | 1021 | Mechanické Přiváděný vzduch 8
799665 | 1011 | Mechanické Přiváděný vzduch 8

# IfcFlowTerminal: CRL-100:CRL-100 (18)
Type - Pset_DistributionFlowElementCommon - Reference: CRL-100
Type - Pset_ManufacturerTypeInformation - Manufacturer: Lindab
Type - Pset_QuantityTakeOff - Reference: CRL-100
Pset_DistributionFlowElementCommon - sets with these values: 2
Name (CRL-100:CRL-100:...) | In | Group
729871 | 1014 | Mechanické Odváděný vzduch 2; Mechanické Odvod_ZAR_1 8
729872 | 1014 | Mechanické Odváděný vzduch 2; Mechanické Odvod_ZAR_1 7
729873 | 1014 | Mechanické Odváděný vzduch 2; Mechanické Odvod_ZAR_1 9
729874 | 1016 | Mechanické Odváděný vzduch 2; Mechanické Odvod_ZAR_1 4
729875 | 1016 | Mechanické Odváděný vzduch 2; Mechanické Odvod_ZAR_1 5
729876 | 1016 | Mechanické Odváděný vzduch 2; Mechanické Odvod_ZAR_1 3
729877 | 1013 | Mechanické Odváděný vzduch 2; Mechanické Odvod_ZAR_2 2
729878 | 1015 | Mechanické Odváděný vzduch 2; Mechanické Odvod_ZAR_1 6
839801 | 1017 | Mechanické Odvod_ZAR_1 2; Mechanické Odváděný vzduch 2
841109 | 1018 | Mechanické Odvod_ZAR_3 1
841353 | 1021 | Mechanické Odvod_ZAR_3 1
841392 | 1022 | Mechanické Odvod_ZAR_3 1
841468 | 1021 | Mechanické Odvod_ZAR_3 1
841521 | 1021 | Mechanické Odvod_ZAR_3 1
841677 | 1019 | Mechanické Odvod_ZAR_3 1
841724 | 1019 | Mechanické Odvod_ZAR_3 1
841757 | 1019 | Mechanické Odvod_ZAR_3 1
1048161 | 1020 | Mechanické Odvod_ZAR_3 1

# IfcFlowTerminal: RC14-160+MBB-160-160-E:RC14-160+MBB-160-160-E (11)
Type - Pset_DistributionFlowElementCommon - Reference: RC14-160+MBB-160-160-E
Type - Pset_ManufacturerTypeInformation - Manufacturer: Lindab
Type - Pset_QuantityTakeOff - Reference: RC14-160+MBB-160-160-E
Pset_DistributionFlowElementCommon - sets with these values: 2
Name (RC14-160+MBB-160-160-E:RC14-160+MBB-160-160-E:...) | In | Group
782976 | 1023 | Mechanické Odváděný vzduch 2; Mechanické Odvod_ZAR_2 3
783163 | 1023 | Mechanické Odváděný vzduch 2; Mechanické Odvod_ZAR_2 3
784647 | 1027 | Mechanické Odváděný vzduch 2; Mechanické Odvod_ZAR_2 2
784648 | 1027 | Mechanické Odváděný vzduch 2; Mechanické Odvod_ZAR_2 2
791894 | 1025 | Mechanické Odváděný vzduch 2; Mechanické Odvod_ZAR_2 2
792062 | 1026 | Mechanické Odváděný vzduch 2; Mechanické Odvod_ZAR_2 2
803364 | 1024 | Mechanické Odváděný vzduch 2; Mechanické Odvod_ZAR_2 2
803365 | 1024 | Mechanické Odváděný vzduch 2; Mechanické Odvod_ZAR_2 2
840149 | 1010 | Mechanické Odvod_ZAR_1 1
840280 | 1012 | Mechanické Odvod_ZAR_1 1
840313 | 1012 | Mechanické Odvod_ZAR_1 1

# IfcFlowTerminal: RC14-160+MBB-160-160-S:RC14-160+MBB-160-160-S (13)
Type - Pset_DistributionFlowElementCommon - Reference: RC14-160+MBB-160-160-S
Type - Pset_ManufacturerTypeInformation - Manufacturer: Lindab
Type - Pset_QuantityTakeOff - Reference: RC14-160+MBB-160-160-S
Pset_DistributionFlowElementCommon - sets with these values: 2
Name (RC14-160+MBB-160-160-S:RC14-160+MBB-160-160-S:...) | In | Group
738046 | 1009 | Mechanické Prívod_ZAR_2 1
738092 | 1009 | Mechanické Prívod_ZAR_2 1
755279 | 1023 | Mechanické Prívod_ZAR_2 1
755354 | 1023 | Mechanické Prívod_ZAR_2 1
783855 | 1024 | Mechanické Prívod_ZAR_2 1
783858 | 1024 | Mechanické Prívod_ZAR_2 1
784013 | 1027 | Mechanické Prívod_ZAR_2 1
784016 | 1027 | Mechanické Prívod_ZAR_2 1
791684 | 1025 | Mechanické Prívod_ZAR_2 1
791740 | 1026 | Mechanické Prívod_ZAR_2 1
838960 | 1010 | Mechanické Prívod_ZAR_1 1
839266 | 1012 | Mechanické Prívod_ZAR_1 1
839430 | 1012 | Mechanické Prívod_ZAR_1 1

# IfcFlowTerminal: RC15-315+MBB-315-315-E:RC15-315+MBB-315-315-E (4)
In: 1011
Type - Pset_DistributionFlowElementCommon - Reference: RC15-315+MBB-315-315-E
Type - Pset_ManufacturerTypeInformation - Manufacturer: Lindab
Type - Pset_QuantityTakeOff - Reference: RC15-315+MBB-315-315-E
Pset_DistributionFlowElementCommon - sets with these values: 2
Group: Mechanické Odvod_ZAR_1 1
Name (RC15-315+MBB-315-315-E:RC15-315+MBB-315-315-E:...)
840722
840872
840882
840890

# IfcFlowTerminal: RCG-400+MBB-250-400-S:RCG-400+MBB-250-400-S (8)
In: 1011
Type - Pset_DistributionFlowElementCommon - Reference: RCG-400+MBB-250-400-S
Type - Pset_ManufacturerTypeInformation - Manufacturer: Lindab
Type - Pset_QuantityTakeOff - Reference: RCG-400+MBB-250-400-S
Pset_DistributionFlowElementCommon - sets with these values: 2
Group: Mechanické Prívod_ZAR_1 1
Name (RCG-400+MBB-250-400-S:RCG-400+MBB-250-400-S:...)
838238
838475
838483
838491
838499
838507
838519
838527

# IfcFlowTerminal: WLA-22-V-NI-810-760:WLA-22-V-NI-810-760 (2)
In: 12NP_STRECHA_VZT
Type - Pset_DistributionFlowElementCommon - Reference: WLA-22-V-NI-810-760
Type - Pset_ManufacturerTypeInformation - Manufacturer: Lindab
Type - Pset_QuantityTakeOff - Reference: WLA-22-V-NI-810-760
Pset_DistributionFlowElementCommon - sets with these values: 2
Name (WLA-22-V-NI-810-760:WLA-22-V-NI-810-760:...) | Group
1105515 | Mechanické Prívod_ZAR_1 1
1105544 | Mechanické Odvod_ZAR_1 1

# IfcFlowTerminal: YGC-200:YGC-200, YGC-200:YGC-200:1106538
In: 10NP_VZT
Type - Pset_DistributionFlowElementCommon - Reference: YGC-200
Type - Pset_ManufacturerTypeInformation - Manufacturer: Lindab
Type - Pset_QuantityTakeOff - Reference: YGC-200
Pset_DistributionFlowElementCommon - sets with these values: 2
Group: Mechanické Odvod_ZAR_3 1

# IfcFlowTerminal: YGC-400:YGC-400 (2)
In: 12NP_STRECHA_VZT
Type - Pset_DistributionFlowElementCommon - Reference: YGC-400
Type - Pset_ManufacturerTypeInformation - Manufacturer: Lindab
Type - Pset_QuantityTakeOff - Reference: YGC-400
Pset_DistributionFlowElementCommon - sets with these values: 2
Name (YGC-400:YGC-400:...) | Group
1151106 | Mechanické Odvod_ZAR_2 1
1151123 | Mechanické Přiváděný vzduch 3

# IfcZone, Výchozí:293242
Pset_ZoneCommon - Reference: Výchozí
